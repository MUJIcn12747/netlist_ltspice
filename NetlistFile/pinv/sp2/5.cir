* ltspice_circuit_netlist
R1 N001 N007 5361.966504592113
R25 N011 N017 5361.966504592113
R2 N001 N008 6027.938050409962
R26 N011 N018 6027.938050409962
R3 N001 N009 7324.723247232474
R27 N011 N019 7324.723247232474
R4 N001 N010 8893.36917562724
R28 N011 N020 8893.36917562724
R5 N002 N007 8649.237472766887
R29 N012 N017 8649.237472766887
R6 N002 N008 14219.19770773639
R30 N012 N018 14219.19770773639
R7 N002 N009 10398.114195914093
R31 N012 N019 10398.114195914093
R8 N002 N010 6647.689216342935
R32 N012 N020 6647.689216342935
R9 N003 N007 10284.974093264249
R33 N013 N017 10284.974093264249
R10 N003 N008 18396.663577386473
R34 N013 N018 18396.663577386473
R11 N003 N009 5720.461095100865
R35 N013 N019 5720.461095100865
R12 N003 N010 7772.122161315585
R36 N013 N020 7772.122161315585
R13 N004 N007 5900.7134363852565
R37 N014 N017 5900.7134363852565
R14 N004 N008 16486.710963455153
R38 N014 N018 16486.710963455153
R15 N004 N009 6004.2347247428925
R39 N014 N019 6004.2347247428925
R16 N004 N010 6945.416375087475
R40 N014 N020 6945.416375087475
R17 N005 N007 9456.884230585996
R41 N015 N017 9456.884230585996
R18 N005 N008 6616.666666666668
R42 N015 N018 6616.666666666668
R19 N005 N009 5000.0
R43 N015 N019 5000.0
R20 N005 N010 10660.580021482278
R44 N015 N020 10660.580021482278
R21 N006 N007 6049.984760743676
R45 N016 N017 6049.984760743676
R22 N006 N008 9566.265060240967
R46 N016 N018 9566.265060240967
R23 N006 N009 5054.749172396231
R47 N016 N019 5054.749172396231
R24 N006 N010 18621.013133208256
R48 N016 N020 18621.013133208256
R49 N001 N011 1000000
R50 N002 N012 1000000
R51 N003 N013 1000000
R52 N004 N014 1000000
R53 N005 N015 1000000
R54 N006 N016 1000000
XU1 0 N001 N999 N998 N011 AD823
XU2 0 N002 N999 N998 N012 AD823
XU3 0 N003 N999 N998 N013 AD823
XU4 0 N004 N999 N998 N014 AD823
XU5 0 N005 N999 N998 N015 AD823
XU6 0 N006 N999 N998 N016 AD823
XU7 N017 0 N999 N998 N007 AD823
XU8 N018 0 N999 N998 N008 AD823
XU9 N019 0 N999 N998 N009 AD823
XU10 N020 0 N999 N998 N010 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 9.380116959064326e-06
I2 0 N002 1.3450292397660817e-06
I3 0 N003 7.3216374269005844e-06
I4 0 N004 9.134502923976608e-06
I5 0 N005 1e-05
I6 0 N006 7.555555555555556e-06
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
