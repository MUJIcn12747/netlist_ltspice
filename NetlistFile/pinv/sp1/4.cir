* ltspice_circuit_netlist
R1 N001 N007 7754.303599374022
R25 N011 N017 7754.303599374022
R2 N001 N008 12295.28535980149
R26 N011 N018 12295.28535980149
R3 N001 N009 7129.4964028776985
R27 N011 N019 7129.4964028776985
R4 N001 N010 14747.023809523811
R28 N011 N020 14747.023809523811
R5 N002 N007 7319.054652880355
R29 N012 N017 7319.054652880355
R6 N002 N008 5272.678903963821
R30 N012 N018 5272.678903963821
R7 N002 N009 9954.79658463084
R31 N012 N019 9954.79658463084
R8 N002 N010 6094.710947109471
R32 N012 N020 6094.710947109471
R9 N003 N007 5656.392694063928
R33 N013 N017 5656.392694063928
R10 N003 N008 11456.647398843932
R34 N013 N018 11456.647398843932
R11 N003 N009 14736.059479553905
R35 N013 N019 14736.059479553905
R12 N003 N010 7370.769802900707
R36 N013 N020 7370.769802900707
R13 N004 N007 7329.881656804735
R37 N014 N017 7329.881656804735
R14 N004 N008 5000.0
R38 N014 N018 5000.0
R15 N004 N009 9979.859013091644
R39 N014 N019 9979.859013091644
R16 N004 N010 6121.0623841877705
R40 N014 N020 6121.0623841877705
R17 N005 N007 9739.55773955774
R41 N015 N017 9739.55773955774
R18 N005 N008 13908.771929824563
R42 N015 N018 13908.771929824563
R19 N005 N009 5948.379351740697
R43 N015 N019 5948.379351740697
R20 N005 N010 12584.126984126986
R44 N015 N020 12584.126984126986
R21 N006 N007 7691.113698098565
R45 N016 N017 7691.113698098565
R22 N006 N008 8524.7311827957
R46 N016 N018 8524.7311827957
R23 N006 N009 6511.169513797635
R47 N016 N019 6511.169513797635
R24 N006 N010 14594.992636229752
R48 N016 N020 14594.992636229752
R49 N001 N011 1000000
R50 N002 N012 1000000
R51 N003 N013 1000000
R52 N004 N014 1000000
R53 N005 N015 1000000
R54 N006 N016 1000000
XU1 0 N001 N999 N998 N011 AD823
XU2 0 N002 N999 N998 N012 AD823
XU3 0 N003 N999 N998 N013 AD823
XU4 0 N004 N999 N998 N014 AD823
XU5 0 N005 N999 N998 N015 AD823
XU6 0 N006 N999 N998 N016 AD823
XU7 N017 0 N999 N998 N007 AD823
XU8 N018 0 N999 N998 N008 AD823
XU9 N019 0 N999 N998 N009 AD823
XU10 N020 0 N999 N998 N010 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 3.065610859728507e-06
I2 0 N002 1e-05
I3 0 N003 4.3099547511312224e-06
I4 0 N004 9.11764705882353e-06
I5 0 N005 1.1651583710407242e-06
I6 0 N006 2.1266968325791853e-06
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
