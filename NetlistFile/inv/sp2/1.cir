* ltspice_circuit_netlist
R1 N009 N001 7741.867992990371
R2 N010 N001 7160.312576441988
R3 N011 N001 6356.989960906453
R4 N012 N001 5244.90560600632
R5 N013 N001 7717.265435640002
R6 N014 N001 8839.48271382484
R7 N015 N001 6973.159252067853
R8 N016 N001 7319.7459401293745
R9 N009 N002 12216.03179879909
R10 N010 N002 10844.475286386552
R11 N011 N002 18328.556655978202
R12 N012 N002 7957.752773737953
R13 N013 N002 5672.491577493999
R14 N014 N002 6201.505994130546
R15 N015 N002 5783.846616517605
R16 N016 N002 11767.650685808743
R17 N009 N003 10528.78617184502
R18 N010 N003 6609.520198180283
R19 N011 N003 7408.84245061444
R20 N012 N003 11608.9813320868
R21 N013 N003 6125.8900692535335
R22 N014 N003 7421.6044215833435
R23 N015 N003 17857.527616879124
R24 N016 N003 5377.737658410848
R25 N009 N004 7843.4636315859325
R26 N010 N004 6321.135082815206
R27 N011 N004 7613.486130404962
R28 N012 N004 12073.422741538254
R29 N013 N004 5905.777227515519
R30 N014 N004 14812.278673142016
R31 N015 N004 13490.194835436385
R32 N016 N004 6869.347884725937
R33 N009 N005 11208.401599688204
R34 N010 N005 8185.656625252993
R35 N011 N005 5355.58524905141
R36 N012 N005 8849.469476036491
R37 N013 N005 5283.4788335169615
R38 N014 N005 13863.813101663527
R39 N015 N005 12225.72032319077
R40 N016 N005 8794.020022309898
R41 N009 N006 5769.326169811619
R42 N010 N006 5409.4827456655385
R43 N011 N006 5767.458512124939
R44 N012 N006 5641.161681368293
R45 N013 N006 6500.00344777434
R46 N014 N006 11648.58891601295
R47 N015 N006 6223.187870908919
R48 N016 N006 11194.175373066913
R49 N009 N007 6428.84725297785
R50 N010 N007 11178.112388478516
R51 N011 N007 9567.549331289238
R52 N012 N007 12682.617422180176
R53 N013 N007 14639.54475603606
R54 N014 N007 8001.190941469681
R55 N015 N007 5566.5805028855875
R56 N016 N007 8721.837294122062
R57 N009 N008 5559.797152976543
R58 N010 N008 5007.872484966419
R59 N011 N008 5043.534984991104
R60 N012 N008 6853.238907902167
R61 N013 N008 6917.186880445795
R62 N014 N008 5781.667554491613
R63 N015 N008 5515.385282926984
R64 N016 N008 5137.038902111899
R65 N025 N001 15918.777860243908
R66 N026 N001 14059.181803559175
R67 N027 N001 12564.895146618843
R68 N028 N001 10637.2742117842
R69 N029 N001 15678.870631155907
R70 N030 N001 17543.152941742763
R71 N031 N001 14228.769352307534
R72 N032 N001 14521.765788102151
R73 N025 N002 25383.305181474992
R74 N026 N002 21843.741158868736
R75 N027 N002 35550.207975322606
R76 N028 N002 15833.292368964496
R77 N029 N002 11353.714393791906
R78 N030 N002 12656.543533137052
R79 N031 N002 11716.137072376954
R80 N032 N002 23559.023525296572
R81 N025 N003 19850.391875947884
R82 N026 N003 13051.566166599296
R83 N027 N003 14815.97024812512
R84 N028 N003 23641.707938751442
R85 N029 N003 12203.188038867676
R86 N030 N003 15213.188816721735
R87 N031 N003 36896.10381819701
R88 N032 N003 10774.621650364748
R89 N025 N004 15547.936879401936
R90 N026 N004 12359.749613725724
R91 N027 N004 15537.045781903122
R92 N028 N004 25289.179145967184
R93 N029 N004 11862.519337711423
R94 N030 N004 28793.650969592196
R95 N031 N004 25559.71736114118
R96 N032 N004 13822.755725405083
R97 N025 N005 22084.683879645767
R98 N026 N005 16255.885667915423
R99 N027 N005 10640.508346830722
R100 N028 N005 18093.845141882437
R101 N029 N005 10533.229958638993
R102 N030 N005 28463.892644762866
R103 N031 N005 24442.82970613279
R104 N032 N005 17391.18770838961
R105 N025 N006 11620.372757006566
R106 N026 N006 10922.798884006772
R107 N027 N006 11563.960514291655
R108 N028 N006 11314.266136797383
R109 N029 N006 12767.565855945883
R110 N030 N006 22850.12014816149
R111 N031 N006 12861.823441071734
R112 N032 N006 22109.79574837624
R113 N025 N007 12623.860860545841
R114 N026 N007 22375.651923644436
R115 N027 N007 18753.107562859153
R116 N028 N007 24996.798831120883
R117 N029 N007 29188.927534362585
R118 N030 N007 16161.074683248537
R119 N031 N007 10983.785146561597
R120 N032 N007 16776.661111771595
R121 N025 N008 11022.344848973982
R122 N026 N008 10021.437924042944
R123 N027 N008 10360.119752195877
R124 N028 N008 13699.731268180896
R125 N029 N008 13909.402558408245
R126 N030 N008 11378.261750463129
R127 N031 N008 11077.051536164685
R128 N032 N008 10320.127876762577
R129 N009 N033 100000
R130 N010 N034 100000
R131 N011 N035 100000
R132 N012 N036 100000
R133 N013 N037 100000
R134 N014 N038 100000
R135 N015 N039 100000
R136 N016 N040 100000
R137 N025 N033 100000
R138 N026 N034 100000
R139 N027 N035 100000
R140 N028 N036 100000
R141 N029 N037 100000
R142 N030 N038 100000
R143 N031 N039 100000
R144 N032 N040 100000
XU1 0 N001 N999 N998 N009 AD823
XU2 0 N002 N999 N998 N010 AD823
XU3 0 N003 N999 N998 N011 AD823
XU4 0 N004 N999 N998 N012 AD823
XU5 0 N005 N999 N998 N013 AD823
XU6 0 N006 N999 N998 N014 AD823
XU7 0 N007 N999 N998 N015 AD823
XU8 0 N008 N999 N998 N016 AD823
XU9 0 N033 N999 N998 N025 AD823
XU10 0 N034 N999 N998 N026 AD823
XU11 0 N035 N999 N998 N027 AD823
XU12 0 N036 N999 N998 N028 AD823
XU13 0 N037 N999 N998 N029 AD823
XU14 0 N038 N999 N998 N030 AD823
XU15 0 N039 N999 N998 N031 AD823
XU16 0 N040 N999 N998 N032 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 5.885486018641812e-06
I2 0 N002 3.5019973368841548e-06
I3 0 N003 6.2316910785619174e-06
I4 0 N004 1e-05
I5 0 N005 4.7802929427430095e-06
I6 0 N006 2.596537949400799e-06
I7 0 N007 8.495339547270308e-06
I8 0 N008 3.0625832223701733e-06
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
