* ltspice_circuit_netlist
R1 N009 N001 7784.917359435953
R2 N010 N001 7120.499022961739
R3 N011 N001 6406.023023445528
R4 N012 N001 5283.893995124638
R5 N013 N001 7611.033241564607
R6 N014 N001 8700.690418959666
R7 N015 N001 7016.340973393295
R8 N016 N001 7271.718493282716
R9 N009 N002 12386.425841174452
R10 N010 N002 11036.219546285156
R11 N011 N002 17433.450912222004
R12 N012 N002 8137.222427005606
R13 N013 N002 5702.768375242251
R14 N014 N002 6284.569171330819
R15 N015 N002 5871.063268390385
R16 N016 N002 11604.984649052718
R17 N009 N003 10560.75949935598
R18 N010 N003 6619.29497984331
R19 N011 N003 7487.966616567299
R20 N012 N003 11537.734190986535
R21 N013 N003 6087.248766748183
R22 N014 N003 7459.925100687536
R23 N015 N003 17653.4418462288
R24 N016 N003 5384.175268354333
R25 N009 N004 7807.623043449714
R26 N010 N004 6334.719881860932
R27 N011 N004 7565.914627251143
R28 N012 N004 12319.559333817739
R29 N013 N004 5900.242622483786
R30 N014 N004 14818.13545826256
R31 N015 N004 13192.854446202304
R32 N016 N004 6833.377382704218
R33 N009 N005 11358.425902668461
R34 N010 N005 8099.2902438517285
R35 N011 N005 5393.6787704608105
R36 N012 N005 9244.694978736272
R37 N013 N005 5284.361407774389
R38 N014 N005 14609.403209888264
R39 N015 N005 12393.195657949303
R40 N016 N005 8756.736358812366
R41 N009 N006 5786.927484131237
R42 N010 N006 5450.80587636384
R43 N011 N006 5811.630182390546
R44 N012 N006 5644.415941119154
R45 N013 N006 6447.879870781698
R46 N014 N006 11383.796236308168
R47 N015 N006 6291.0036841526835
R48 N016 N006 11179.111990110123
R49 N009 N007 6435.951913856736
R50 N010 N007 10968.985328860632
R51 N011 N007 9532.364204531674
R52 N012 N007 12604.133108646265
R53 N013 N007 14873.31839156858
R54 N014 N007 7993.292412925352
R55 N015 N007 5495.995964018173
R56 N016 N007 8652.972642948647
R57 N009 N008 5584.618038704388
R58 N010 N008 5000.0
R59 N011 N008 5077.970657649236
R60 N012 N008 6766.529096367498
R61 N013 N008 6877.120888673454
R62 N014 N008 5724.033925846216
R63 N015 N008 5504.903188889826
R64 N016 N008 5146.0400638182455
R65 N025 N001 15429.357365366108
R66 N026 N001 14000.68049310758
R67 N027 N001 12887.620791809748
R68 N028 N001 10610.261685780373
R69 N029 N001 15355.111975471116
R70 N030 N001 17346.842188095827
R71 N031 N001 14099.88047902965
R72 N032 N001 14131.232278071642
R73 N025 N002 24865.381430440924
R74 N026 N002 22138.43093566747
R75 N027 N002 35569.85106439087
R76 N028 N002 16335.611171228755
R77 N029 N002 11454.241551465948
R78 N030 N002 12746.013903463261
R79 N031 N002 11676.74716448311
R80 N032 N002 24786.32366781296
R81 N025 N003 21224.52366321882
R82 N026 N003 13656.08621732431
R83 N027 N003 14960.344578269582
R84 N028 N003 22195.707034249088
R85 N029 N003 12144.469062422679
R86 N030 N003 14782.639516752723
R87 N031 N003 36588.62352749755
R88 N032 N003 10813.592462584606
R89 N025 N004 15839.43188262529
R90 N026 N004 12857.474408066122
R91 N027 N004 15349.969167040721
R92 N028 N004 25223.161099186746
R93 N029 N004 11769.779657779905
R94 N030 N004 28681.72523171541
R95 N031 N004 26581.611925509027
R96 N032 N004 13525.239120563647
R97 N025 N005 22003.795016893826
R98 N026 N005 16475.6078882491
R99 N027 N005 10802.234204854225
R100 N028 N005 18499.33541932816
R101 N029 N005 10569.678748098318
R102 N030 N005 27440.14406449592
R103 N031 N005 24008.345457277595
R104 N032 N005 17797.438327654774
R105 N025 N006 11442.245279251392
R106 N026 N006 10975.283819736662
R107 N027 N006 11371.687854700422
R108 N028 N006 11283.715314314573
R109 N029 N006 12898.401748816612
R110 N030 N006 22690.856661842514
R111 N031 N006 12810.795306140324
R112 N032 N006 22562.17371704459
R113 N025 N007 12580.084913285442
R114 N026 N007 21897.053097805157
R115 N027 N007 19607.262000428156
R116 N028 N007 25206.19318554692
R117 N029 N007 30818.148406617856
R118 N030 N007 16468.039704063503
R119 N031 N007 11028.790868420236
R120 N032 N007 17372.757947780607
R121 N025 N008 11272.16698573704
R122 N026 N008 10020.466741009335
R123 N027 N008 9941.952832944642
R124 N028 N008 13449.6898688552
R125 N029 N008 13961.902225146565
R126 N030 N008 11550.391727838893
R127 N031 N008 10796.583214309265
R128 N032 N008 10380.473173807328
R129 N009 N033 100000
R130 N010 N034 100000
R131 N011 N035 100000
R132 N012 N036 100000
R133 N013 N037 100000
R134 N014 N038 100000
R135 N015 N039 100000
R136 N016 N040 100000
R137 N025 N033 100000
R138 N026 N034 100000
R139 N027 N035 100000
R140 N028 N036 100000
R141 N029 N037 100000
R142 N030 N038 100000
R143 N031 N039 100000
R144 N032 N040 100000
XU1 0 N001 N999 N998 N009 AD823
XU2 0 N002 N999 N998 N010 AD823
XU3 0 N003 N999 N998 N011 AD823
XU4 0 N004 N999 N998 N012 AD823
XU5 0 N005 N999 N998 N013 AD823
XU6 0 N006 N999 N998 N014 AD823
XU7 0 N007 N999 N998 N015 AD823
XU8 0 N008 N999 N998 N016 AD823
XU9 0 N033 N999 N998 N025 AD823
XU10 0 N034 N999 N998 N026 AD823
XU11 0 N035 N999 N998 N027 AD823
XU12 0 N036 N999 N998 N028 AD823
XU13 0 N037 N999 N998 N029 AD823
XU14 0 N038 N999 N998 N030 AD823
XU15 0 N039 N999 N998 N031 AD823
XU16 0 N040 N999 N998 N032 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 4.481268011527378e-06
I2 0 N002 7.896253602305477e-06
I3 0 N003 6.916426512968299e-06
I4 0 N004 9.466858789625361e-06
I5 0 N005 6.628242074927954e-06
I6 0 N006 5.317002881844381e-06
I7 0 N007 7.291066282420749e-06
I8 0 N008 1e-05
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
