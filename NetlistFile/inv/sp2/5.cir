* ltspice_circuit_netlist
R1 N009 N001 7651.902028041758
R2 N010 N001 7173.079482755519
R3 N011 N001 6343.419954553938
R4 N012 N001 5253.875201637021
R5 N013 N001 7622.079983928527
R6 N014 N001 8846.844382581052
R7 N015 N001 7090.840087016604
R8 N016 N001 7405.180897491089
R9 N009 N002 12229.469665004512
R10 N010 N002 10882.593958829035
R11 N011 N002 17114.40930972041
R12 N012 N002 8157.239490876834
R13 N013 N002 5694.125568001603
R14 N014 N002 6313.018276625006
R15 N015 N002 5847.227285455964
R16 N016 N002 11718.931218337091
R17 N009 N003 10517.697544443996
R18 N010 N003 6626.449666381395
R19 N011 N003 7535.932121386389
R20 N012 N003 11578.181521894561
R21 N013 N003 6075.698002453151
R22 N014 N003 7518.935784531262
R23 N015 N003 17735.14122220249
R24 N016 N003 5406.007516088797
R25 N009 N004 7899.276635604395
R26 N010 N004 6310.346062754459
R27 N011 N004 7641.349365977172
R28 N012 N004 12301.360536061125
R29 N013 N004 5893.916073214207
R30 N014 N004 14876.125587342525
R31 N015 N004 12878.251125126573
R32 N016 N004 6923.89883375819
R33 N009 N005 11327.958151867684
R34 N010 N005 8137.090696300076
R35 N011 N005 5371.605644054384
R36 N012 N005 8928.395270096014
R37 N013 N005 5280.267743596047
R38 N014 N005 13785.510059432074
R39 N015 N005 12405.108281412984
R40 N016 N005 8906.057567547052
R41 N009 N006 5847.7021246122995
R42 N010 N006 5458.362449040749
R43 N011 N006 5793.668235896562
R44 N012 N006 5747.283759684092
R45 N013 N006 6408.615796667326
R46 N014 N006 11730.26946714143
R47 N015 N006 6295.5504486625005
R48 N016 N006 11036.696071948874
R49 N009 N007 6390.564276793226
R50 N010 N007 10915.542451285022
R51 N011 N007 9456.510370944476
R52 N012 N007 12525.513856411333
R53 N013 N007 14672.739994096813
R54 N014 N007 8048.248043282194
R55 N015 N007 5571.289627523178
R56 N016 N007 8626.015109987527
R57 N009 N008 5590.912191796681
R58 N010 N008 5000.0
R59 N011 N008 5061.611952255507
R60 N012 N008 6787.97456799047
R61 N013 N008 6836.629484069463
R62 N014 N008 5744.641072759628
R63 N015 N008 5519.839302674456
R64 N016 N008 5184.064442851782
R65 N025 N001 15264.973616900365
R66 N026 N001 14084.502446671577
R67 N027 N001 12676.126174277464
R68 N028 N001 10494.844750363312
R69 N029 N001 15730.64679811727
R70 N030 N001 17529.52538422523
R71 N031 N001 14058.132190371656
R72 N032 N001 14520.904168273073
R73 N025 N002 24711.62918625082
R74 N026 N002 22907.617479689794
R75 N027 N002 33982.893770974886
R76 N028 N002 15961.537342067075
R77 N029 N002 11281.97276306434
R78 N030 N002 12672.682290987637
R79 N031 N002 11481.835682849252
R80 N032 N002 23374.670613070502
R81 N025 N003 20678.65859809699
R82 N026 N003 13169.185369003157
R83 N027 N003 15029.711594743281
R84 N028 N003 22494.85947162589
R85 N029 N003 12291.16419336959
R86 N030 N003 14939.993987189462
R87 N031 N003 34572.56440721147
R88 N032 N003 10826.812701281133
R89 N025 N004 15576.390278571318
R90 N026 N004 12487.658638672498
R91 N027 N004 15035.90751472003
R92 N028 N004 23499.050541660148
R93 N029 N004 11832.23840293603
R94 N030 N004 29389.626243776955
R95 N031 N004 26309.506751363908
R96 N032 N004 14098.952296503056
R97 N025 N005 22118.110760090694
R98 N026 N005 16391.24383232031
R99 N027 N005 10763.718957603218
R100 N028 N005 18200.645542847957
R101 N029 N005 10545.620614263844
R102 N030 N005 28116.480225683015
R103 N031 N005 24190.92761713949
R104 N032 N005 17453.484953340907
R105 N025 N006 11438.611776708218
R106 N026 N006 11077.447370307264
R107 N027 N006 11571.59321340624
R108 N028 N006 11495.63293468837
R109 N029 N006 12901.16121097648
R110 N030 N006 23941.500927790923
R111 N031 N006 12712.326106687166
R112 N032 N006 22857.44928011834
R113 N025 N007 13114.026732453074
R114 N026 N007 21791.020198290807
R115 N027 N007 18941.997321931944
R116 N028 N007 25952.98278269416
R117 N029 N007 28956.108232851388
R118 N030 N007 16278.90998492483
R119 N031 N007 11023.75896577565
R120 N032 N007 17171.620089687858
R121 N025 N008 11269.561961354546
R122 N026 N008 9994.224191490359
R123 N027 N008 10136.565670720232
R124 N028 N008 13872.416656038355
R125 N029 N008 13509.50759270007
R126 N030 N008 11341.379616059361
R127 N031 N008 11060.873367064392
R128 N032 N008 10329.347948985907
R129 N009 N033 100000
R130 N010 N034 100000
R131 N011 N035 100000
R132 N012 N036 100000
R133 N013 N037 100000
R134 N014 N038 100000
R135 N015 N039 100000
R136 N016 N040 100000
R137 N025 N033 100000
R138 N026 N034 100000
R139 N027 N035 100000
R140 N028 N036 100000
R141 N029 N037 100000
R142 N030 N038 100000
R143 N031 N039 100000
R144 N032 N040 100000
XU1 0 N001 N999 N998 N009 AD823
XU2 0 N002 N999 N998 N010 AD823
XU3 0 N003 N999 N998 N011 AD823
XU4 0 N004 N999 N998 N012 AD823
XU5 0 N005 N999 N998 N013 AD823
XU6 0 N006 N999 N998 N014 AD823
XU7 0 N007 N999 N998 N015 AD823
XU8 0 N008 N999 N998 N016 AD823
XU9 0 N033 N999 N998 N025 AD823
XU10 0 N034 N999 N998 N026 AD823
XU11 0 N035 N999 N998 N027 AD823
XU12 0 N036 N999 N998 N028 AD823
XU13 0 N037 N999 N998 N029 AD823
XU14 0 N038 N999 N998 N030 AD823
XU15 0 N039 N999 N998 N031 AD823
XU16 0 N040 N999 N998 N032 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 4.4569288389513114e-06
I2 0 N002 2.471910112359551e-06
I3 0 N003 3.2209737827715358e-06
I4 0 N004 5.543071161048689e-06
I5 0 N005 1e-05
I6 0 N006 2.4906367041198506e-06
I7 0 N007 8.970037453183521e-06
I8 0 N008 8.55805243445693e-06
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
