* ltspice_circuit_netlist
R1 N009 N001 7652.759352307546
R2 N010 N001 7182.475222491207
R3 N011 N001 6374.399522525232
R4 N012 N001 5288.0033616328665
R5 N013 N001 7638.67926748201
R6 N014 N001 8883.865565111282
R7 N015 N001 7054.495839299006
R8 N016 N001 7302.856309270603
R9 N009 N002 12668.286427117904
R10 N010 N002 10940.735644210035
R11 N011 N002 17077.655447545203
R12 N012 N002 8071.184855061298
R13 N013 N002 5712.776196884173
R14 N014 N002 6262.066034782667
R15 N015 N002 5834.994634516994
R16 N016 N002 11705.910643491074
R17 N009 N003 10479.799067204302
R18 N010 N003 6588.56062317411
R19 N011 N003 7382.4780842445925
R20 N012 N003 11800.44313078003
R21 N013 N003 6099.108570675192
R22 N014 N003 7388.35585297988
R23 N015 N003 18388.012477676322
R24 N016 N003 5389.898545008462
R25 N009 N004 7759.545277070869
R26 N010 N004 6328.372291980371
R27 N011 N004 7654.873708413365
R28 N012 N004 12447.276878890483
R29 N013 N004 5848.707899965397
R30 N014 N004 15084.980156541635
R31 N015 N004 13398.854671862502
R32 N016 N004 6957.495442803966
R33 N009 N005 11245.928294269595
R34 N010 N005 8207.097775094537
R35 N011 N005 5396.701985032275
R36 N012 N005 8804.12348984655
R37 N013 N005 5266.121262805869
R38 N014 N005 13997.407913650211
R39 N015 N005 12477.459255630627
R40 N016 N005 8856.718986299631
R41 N009 N006 5739.847873115226
R42 N010 N006 5433.498658851914
R43 N011 N006 5747.2436922768065
R44 N012 N006 5733.451280771401
R45 N013 N006 6431.650615445939
R46 N014 N006 11691.702404762706
R47 N015 N006 6249.771757954982
R48 N016 N006 11193.009212304389
R49 N009 N007 6479.120357620494
R50 N010 N007 11110.947520028118
R51 N011 N007 9512.066045874542
R52 N012 N007 12860.023111145103
R53 N013 N007 14555.876741999848
R54 N014 N007 8099.91052811795
R55 N015 N007 5513.244220859389
R56 N016 N007 8643.724708214148
R57 N009 N008 5547.257074531183
R58 N010 N008 5000.0
R59 N011 N008 5078.00632899314
R60 N012 N008 6711.791692261414
R61 N013 N008 6912.467414217692
R62 N014 N008 5757.7027962332095
R63 N015 N008 5504.528608054517
R64 N016 N008 5166.848863540575
R65 N025 N001 15183.260947521541
R66 N026 N001 14343.310548500012
R67 N027 N001 12824.882654904377
R68 N028 N001 10549.828562212888
R69 N029 N001 15225.834038848907
R70 N030 N001 17751.33220252672
R71 N031 N001 13825.557489908346
R72 N032 N001 14422.07326720918
R73 N025 N002 25907.249158248575
R74 N026 N002 21532.509326537514
R75 N027 N002 33443.223348398125
R76 N028 N002 15924.097636302597
R77 N029 N002 11748.500248215161
R78 N030 N002 12629.369143536605
R79 N031 N002 11830.106476451816
R80 N032 N002 23859.638209224588
R81 N025 N003 21133.904431919673
R82 N026 N003 13339.651321755997
R83 N027 N003 15038.571368067922
R84 N028 N003 22724.730799091347
R85 N029 N003 12064.135117622702
R86 N030 N003 15024.949859403663
R87 N031 N003 33794.665211470754
R88 N032 N003 10931.877073274207
R89 N025 N004 15559.058542951096
R90 N026 N004 12560.53153152715
R91 N027 N004 15113.447285216598
R92 N028 N004 24146.78807678006
R93 N029 N004 11587.469863826982
R94 N030 N004 29305.607496164812
R95 N031 N004 26508.08948707199
R96 N032 N004 13410.947517666222
R97 N025 N005 22425.757202804634
R98 N026 N005 16346.487973262532
R99 N027 N005 10920.285761091995
R100 N028 N005 18074.88262039555
R101 N029 N005 10510.697550165296
R102 N030 N005 26721.354834801125
R103 N031 N005 25052.26447705506
R104 N032 N005 18008.3224653655
R105 N025 N006 11622.350964548292
R106 N026 N006 10904.6354318631
R107 N027 N006 11466.047274898616
R108 N028 N006 11351.826604238942
R109 N029 N006 12894.752472420943
R110 N030 N006 22752.314250095624
R111 N031 N006 12752.821458323013
R112 N032 N006 21605.174084772872
R113 N025 N007 12883.701765030128
R114 N026 N007 22269.93861689846
R115 N027 N007 18966.650005495976
R116 N028 N007 24683.883169108827
R117 N029 N007 31093.000054485412
R118 N030 N007 15680.150699530044
R119 N031 N007 11027.914655440181
R120 N032 N007 17320.17437731195
R121 N025 N008 11205.542563480878
R122 N026 N008 9980.297696021691
R123 N027 N008 10187.924405756716
R124 N028 N008 13458.28482185325
R125 N029 N008 14049.576603958349
R126 N030 N008 11670.339466180401
R127 N031 N008 11037.133197739955
R128 N032 N008 10328.709887448478
R129 N009 N033 100000
R130 N010 N034 100000
R131 N011 N035 100000
R132 N012 N036 100000
R133 N013 N037 100000
R134 N014 N038 100000
R135 N015 N039 100000
R136 N016 N040 100000
R137 N025 N033 100000
R138 N026 N034 100000
R139 N027 N035 100000
R140 N028 N036 100000
R141 N029 N037 100000
R142 N030 N038 100000
R143 N031 N039 100000
R144 N032 N040 100000
XU1 0 N001 N999 N998 N009 AD823
XU2 0 N002 N999 N998 N010 AD823
XU3 0 N003 N999 N998 N011 AD823
XU4 0 N004 N999 N998 N012 AD823
XU5 0 N005 N999 N998 N013 AD823
XU6 0 N006 N999 N998 N014 AD823
XU7 0 N007 N999 N998 N015 AD823
XU8 0 N008 N999 N998 N016 AD823
XU9 0 N033 N999 N998 N025 AD823
XU10 0 N034 N999 N998 N026 AD823
XU11 0 N035 N999 N998 N027 AD823
XU12 0 N036 N999 N998 N028 AD823
XU13 0 N037 N999 N998 N029 AD823
XU14 0 N038 N999 N998 N030 AD823
XU15 0 N039 N999 N998 N031 AD823
XU16 0 N040 N999 N998 N032 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 1e-05
I2 0 N002 5.686746987951807e-06
I3 0 N003 5.289156626506024e-06
I4 0 N004 2.072289156626506e-06
I5 0 N005 5.987951807228915e-06
I6 0 N006 8.156626506024097e-06
I7 0 N007 6.301204819277109e-06
I8 0 N008 6.590361445783132e-06
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
