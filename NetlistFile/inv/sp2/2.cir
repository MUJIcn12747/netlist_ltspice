* ltspice_circuit_netlist
R1 N009 N001 7747.788770049991
R2 N010 N001 7143.451246054176
R3 N011 N001 6353.408703996794
R4 N012 N001 5268.251023968222
R5 N013 N001 7689.088875794046
R6 N014 N001 8585.059138698183
R7 N015 N001 7044.151404502445
R8 N016 N001 7289.088570459602
R9 N009 N002 12669.729371873269
R10 N010 N002 11165.07236803951
R11 N011 N002 17109.41072401839
R12 N012 N002 7917.224473391118
R13 N013 N002 5630.26504811054
R14 N014 N002 6292.651406741838
R15 N015 N002 5760.235226719242
R16 N016 N002 11639.446246083913
R17 N009 N003 10631.853071847287
R18 N010 N003 6690.3656249941305
R19 N011 N003 7428.477230440343
R20 N012 N003 11723.317586236204
R21 N013 N003 6053.929026004184
R22 N014 N003 7292.3921859400925
R23 N015 N003 17648.85757351804
R24 N016 N003 5382.144045278557
R25 N009 N004 7770.374126694742
R26 N010 N004 6354.969187633447
R27 N011 N004 7658.926799908735
R28 N012 N004 12357.879795761623
R29 N013 N004 5890.755551911581
R30 N014 N004 15221.099211844452
R31 N015 N004 12935.200555809262
R32 N016 N004 6897.905284955257
R33 N009 N005 11395.076096046932
R34 N010 N005 8157.052464521204
R35 N011 N005 5390.4393610513835
R36 N012 N005 8998.408757772411
R37 N013 N005 5226.017509464344
R38 N014 N005 14234.90843470705
R39 N015 N005 12470.252714005099
R40 N016 N005 8879.261283298709
R41 N009 N006 5784.64141640768
R42 N010 N006 5472.69406156142
R43 N011 N006 5746.763423446781
R44 N012 N006 5640.951167307147
R45 N013 N006 6468.484464513917
R46 N014 N006 11795.916424564815
R47 N015 N006 6301.94413580424
R48 N016 N006 11109.465645998815
R49 N009 N007 6402.047046176725
R50 N010 N007 11284.395272607819
R51 N011 N007 9498.275129240174
R52 N012 N007 12670.745596110959
R53 N013 N007 14781.461801470736
R54 N014 N007 7962.092986254376
R55 N015 N007 5499.251288184811
R56 N016 N007 8607.63673305307
R57 N009 N008 5554.820903519122
R58 N010 N008 5000.276820557662
R59 N011 N008 5070.275799884097
R60 N012 N008 6752.8774878090135
R61 N013 N008 6865.000388796866
R62 N014 N008 5722.886551332752
R63 N015 N008 5511.383889456023
R64 N016 N008 5119.648106279477
R65 N025 N001 15625.748670443527
R66 N026 N001 14504.386405896188
R67 N027 N001 12813.389466265155
R68 N028 N001 10646.768383932165
R69 N029 N001 15431.740772866962
R70 N030 N001 17719.205270122766
R71 N031 N001 14233.479512599257
R72 N032 N001 15032.998858359959
R73 N025 N002 25935.49470823786
R74 N026 N002 22373.19668784385
R75 N027 N002 35080.329987886464
R76 N028 N002 15954.51619401973
R77 N029 N002 11393.504905847036
R78 N030 N002 12408.431481032218
R79 N031 N002 11823.017185623432
R80 N032 N002 22780.53097894875
R81 N025 N003 20590.924581640167
R82 N026 N003 13210.836733769642
R83 N027 N003 14822.705232746306
R84 N028 N003 23767.40642583742
R85 N029 N003 12186.827740207926
R86 N030 N003 15049.457961847142
R87 N031 N003 33416.26307962714
R88 N032 N003 10731.965250566416
R89 N025 N004 15324.249242381087
R90 N026 N004 12882.07825222228
R91 N027 N004 15447.36004021291
R92 N028 N004 24869.190796976225
R93 N029 N004 11860.558707989123
R94 N030 N004 29946.80314325978
R95 N031 N004 25926.092852721904
R96 N032 N004 13845.372005610514
R97 N025 N005 21544.2396908526
R98 N026 N005 16003.479778175606
R99 N027 N005 10618.267699350197
R100 N028 N005 17737.45889360812
R101 N029 N005 10386.961634759276
R102 N030 N005 27799.478084573166
R103 N031 N005 24300.387296472712
R104 N032 N005 17692.51005034037
R105 N025 N006 11518.446504712861
R106 N026 N006 10941.745831079486
R107 N027 N006 11573.741979213868
R108 N028 N006 11335.083056824424
R109 N029 N006 13059.586769840245
R110 N030 N006 23817.51902363383
R111 N031 N006 12698.237135344974
R112 N032 N006 21689.69775558531
R113 N025 N007 12828.30655960657
R114 N026 N007 22807.054899979707
R115 N027 N007 18970.923949443517
R116 N028 N007 24672.519052566462
R117 N029 N007 30473.958546177357
R118 N030 N007 16119.6697092465
R119 N031 N007 11003.311846528812
R120 N032 N007 17490.549674719965
R121 N025 N008 11138.632369398765
R122 N026 N008 9984.357244221763
R123 N027 N008 10064.389372976217
R124 N028 N008 13609.592824911197
R125 N029 N008 13755.892480991786
R126 N030 N008 11439.417159991968
R127 N031 N008 11125.852914346093
R128 N032 N008 10275.511339393104
R129 N009 N033 100000
R130 N010 N034 100000
R131 N011 N035 100000
R132 N012 N036 100000
R133 N013 N037 100000
R134 N014 N038 100000
R135 N015 N039 100000
R136 N016 N040 100000
R137 N025 N033 100000
R138 N026 N034 100000
R139 N027 N035 100000
R140 N028 N036 100000
R141 N029 N037 100000
R142 N030 N038 100000
R143 N031 N039 100000
R144 N032 N040 100000
XU1 0 N001 N999 N998 N009 AD823
XU2 0 N002 N999 N998 N010 AD823
XU3 0 N003 N999 N998 N011 AD823
XU4 0 N004 N999 N998 N012 AD823
XU5 0 N005 N999 N998 N013 AD823
XU6 0 N006 N999 N998 N014 AD823
XU7 0 N007 N999 N998 N015 AD823
XU8 0 N008 N999 N998 N016 AD823
XU9 0 N033 N999 N998 N025 AD823
XU10 0 N034 N999 N998 N026 AD823
XU11 0 N035 N999 N998 N027 AD823
XU12 0 N036 N999 N998 N028 AD823
XU13 0 N037 N999 N998 N029 AD823
XU14 0 N038 N999 N998 N030 AD823
XU15 0 N039 N999 N998 N031 AD823
XU16 0 N040 N999 N998 N032 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 3.887640449438202e-06
I2 0 N002 6.359550561797753e-06
I3 0 N003 2.853932584269663e-06
I4 0 N004 1.651685393258427e-06
I5 0 N005 1e-05
I6 0 N006 5.404494382022472e-06
I7 0 N007 9.359550561797752e-06
I8 0 N008 9.988764044943822e-06
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
