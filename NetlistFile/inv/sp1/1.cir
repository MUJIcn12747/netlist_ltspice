* ltspice_circuit_netlist
R1 N009 N001 12755.174547356854
R2 N010 N001 5146.840966356635
R3 N011 N001 5714.102679910322
R4 N012 N001 19230.550088519885
R5 N013 N001 11628.150409831727
R6 N014 N001 6047.696710345091
R7 N015 N001 16605.71738796337
R8 N016 N001 6648.322085866146
R9 N009 N002 17463.067316832483
R10 N010 N002 6988.723890936939
R11 N011 N002 17357.152401580217
R12 N012 N002 12748.576618209727
R13 N013 N002 5179.681941786715
R14 N014 N002 9117.403239839066
R15 N015 N002 8760.365515126694
R16 N016 N002 9310.401103206219
R17 N009 N003 6924.853532254122
R18 N010 N003 11868.060674115643
R19 N011 N003 8227.547880644937
R20 N012 N003 9172.155115212348
R21 N013 N003 13160.721017060876
R22 N014 N003 7991.824458530697
R23 N015 N003 5682.137177640709
R24 N016 N003 8006.673399744469
R25 N009 N004 5133.2480449879395
R26 N010 N004 5839.458281041985
R27 N011 N004 11130.237878070351
R28 N012 N004 12686.155413000064
R29 N013 N004 13913.026472133866
R30 N014 N004 10656.507932742443
R31 N015 N004 6962.921675755562
R32 N016 N004 5893.093542593164
R33 N009 N005 6774.052477136635
R34 N010 N005 6928.310294496527
R35 N011 N005 9303.267845910097
R36 N012 N005 9303.712534748911
R37 N013 N005 6518.822753224803
R38 N014 N005 9848.343954578628
R39 N015 N005 8723.155968951236
R40 N016 N005 11396.118522302633
R41 N009 N006 17004.844629729207
R42 N010 N006 8365.689425681721
R43 N011 N006 5720.905495104135
R44 N012 N006 6764.120749435658
R45 N013 N006 10748.445181615547
R46 N014 N006 8250.369148889005
R47 N015 N006 13026.068466286491
R48 N016 N006 19683.402327914508
R49 N009 N007 5247.839091704435
R50 N010 N007 5438.34470771994
R51 N011 N007 19443.8332263899
R52 N012 N007 9346.427761889629
R53 N013 N007 5304.185544692003
R54 N014 N007 15110.98883863872
R55 N015 N007 5000.0
R56 N016 N007 9827.07400066208
R57 N009 N008 19965.13990455363
R58 N010 N008 6820.218238028546
R59 N011 N008 9455.868566329178
R60 N012 N008 5626.385276574693
R61 N013 N008 11851.7872295316
R62 N014 N008 5132.988689195674
R63 N015 N008 18619.828020100005
R64 N016 N008 15450.704780391568
R65 N025 N001 25305.712165353023
R66 N026 N001 10111.594031769464
R67 N027 N001 11552.52431858495
R68 N028 N001 38925.92991561978
R69 N029 N001 23497.73562914453
R70 N030 N001 11965.075382925945
R71 N031 N001 34789.74183083362
R72 N032 N001 13454.80263412433
R73 N025 N002 33872.39436977216
R74 N026 N002 13834.396660744776
R75 N027 N002 37925.61644875513
R76 N028 N002 26255.645057097227
R77 N029 N002 10403.457829859397
R78 N030 N002 17983.575495919078
R79 N031 N002 17684.793483487243
R80 N032 N002 18481.358541596033
R81 N025 N003 14183.864376389947
R82 N026 N003 24230.73377223648
R83 N027 N003 16730.34683597125
R84 N028 N003 18271.40303861807
R85 N029 N003 27384.337253124388
R86 N030 N003 15894.573888074308
R87 N031 N003 11219.028159329198
R88 N032 N003 15919.744070863804
R89 N025 N004 10226.882525187253
R90 N026 N004 11558.205832052274
R91 N027 N004 21371.107022608427
R92 N028 N004 25243.049445941884
R93 N029 N004 28097.63860933033
R94 N030 N004 20749.07695835119
R95 N031 N004 13846.112660106348
R96 N032 N004 12074.464308166807
R97 N025 N005 13617.336316346646
R98 N026 N005 13978.119612182394
R99 N027 N005 18897.59304383638
R100 N028 N005 19009.252119170593
R101 N029 N005 12731.063035151405
R102 N030 N005 19138.68554278368
R103 N031 N005 18147.931977822085
R104 N032 N005 22458.138762984774
R105 N025 N006 36903.387039768444
R106 N026 N006 16863.980187407782
R107 N027 N006 11552.186473892514
R108 N028 N006 13779.256844794063
R109 N029 N006 21712.816360440618
R110 N030 N006 16231.06863230776
R111 N031 N006 27018.59040619769
R112 N032 N006 41453.76169563434
R113 N025 N007 10386.293586209616
R114 N026 N007 10788.65276983199
R115 N027 N007 37253.40286722681
R116 N028 N007 18247.98455654558
R117 N029 N007 10628.8951599547
R118 N030 N007 31573.023154382077
R119 N031 N007 9673.570781303833
R120 N032 N007 19523.99483078326
R121 N025 N008 40692.52024318093
R122 N026 N008 13840.221385938768
R123 N027 N008 19570.05527232981
R124 N028 N008 11383.534947047609
R125 N029 N008 23753.617116849906
R126 N030 N008 10277.668128248733
R127 N031 N008 36111.90790122647
R128 N032 N008 31639.281823953406
R129 N009 N033 100000
R130 N010 N034 100000
R131 N011 N035 100000
R132 N012 N036 100000
R133 N013 N037 100000
R134 N014 N038 100000
R135 N015 N039 100000
R136 N016 N040 100000
R137 N025 N033 100000
R138 N026 N034 100000
R139 N027 N035 100000
R140 N028 N036 100000
R141 N029 N037 100000
R142 N030 N038 100000
R143 N031 N039 100000
R144 N032 N040 100000
XU1 0 N001 N999 N998 N009 AD823
XU2 0 N002 N999 N998 N010 AD823
XU3 0 N003 N999 N998 N011 AD823
XU4 0 N004 N999 N998 N012 AD823
XU5 0 N005 N999 N998 N013 AD823
XU6 0 N006 N999 N998 N014 AD823
XU7 0 N007 N999 N998 N015 AD823
XU8 0 N008 N999 N998 N016 AD823
XU9 0 N033 N999 N998 N025 AD823
XU10 0 N034 N999 N998 N026 AD823
XU11 0 N035 N999 N998 N027 AD823
XU12 0 N036 N999 N998 N028 AD823
XU13 0 N037 N999 N998 N029 AD823
XU14 0 N038 N999 N998 N030 AD823
XU15 0 N039 N999 N998 N031 AD823
XU16 0 N040 N999 N998 N032 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 5.80135440180587e-06
I2 0 N002 8.216704288939054e-06
I3 0 N003 2.4379232505643347e-06
I4 0 N004 9.661399548532732e-06
I5 0 N005 3.7923250564334093e-06
I6 0 N006 1e-05
I7 0 N007 9.006772009029347e-06
I8 0 N008 1.4108352144469528e-06
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
