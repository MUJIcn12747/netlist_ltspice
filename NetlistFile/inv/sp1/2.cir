* ltspice_circuit_netlist
R1 N009 N001 12737.755625155243
R2 N010 N001 5064.967492561593
R3 N011 N001 5736.5633992238445
R4 N012 N001 19341.27027140561
R5 N013 N001 11563.153482987569
R6 N014 N001 6026.390891173494
R7 N015 N001 16325.456806517093
R8 N016 N001 6606.453367424618
R9 N009 N002 17399.410864699756
R10 N010 N002 6999.899015041549
R11 N011 N002 17543.254290925182
R12 N012 N002 13001.235264569576
R13 N013 N002 5144.06747158593
R14 N014 N002 9050.176425205442
R15 N015 N002 8703.810231058342
R16 N016 N002 9447.479616696228
R17 N009 N003 6968.098767076935
R18 N010 N003 12092.774717330296
R19 N011 N003 8187.9707212041685
R20 N012 N003 9322.996631591359
R21 N013 N003 13277.262893815603
R22 N014 N003 7951.771284351072
R23 N015 N003 5695.025883678492
R24 N016 N003 7957.446342217214
R25 N009 N004 5167.351704338904
R26 N010 N004 5835.257722673407
R27 N011 N004 10902.481222557868
R28 N012 N004 12785.693814165466
R29 N013 N004 14277.678174983077
R30 N014 N004 10536.881438212344
R31 N015 N004 6943.594227491506
R32 N016 N004 5988.485351475804
R33 N009 N005 6833.937544820249
R34 N010 N005 6914.937238850525
R35 N011 N005 9391.704881129259
R36 N012 N005 9219.31074196288
R37 N013 N005 6597.255348319791
R38 N014 N005 9771.291307541744
R39 N015 N005 8792.570854503538
R40 N016 N005 11220.077948241507
R41 N009 N006 17408.1013008825
R42 N010 N006 8360.62899206298
R43 N011 N006 5705.463850763805
R44 N012 N006 6773.564009762978
R45 N013 N006 10771.599354705304
R46 N014 N006 8135.056241878485
R47 N015 N006 12993.935759196509
R48 N016 N006 19832.55553967469
R49 N009 N007 5224.409413098664
R50 N010 N007 5417.88757876474
R51 N011 N007 18786.950606236696
R52 N012 N007 9185.785741751231
R53 N013 N007 5295.394956097891
R54 N014 N007 15210.290665973585
R55 N015 N007 5062.89957884112
R56 N016 N007 9520.158307207175
R57 N009 N008 19457.16153920937
R58 N010 N008 6852.21200411373
R59 N011 N008 9685.696958511731
R60 N012 N008 5639.029303777868
R61 N013 N008 11956.069830178505
R62 N014 N008 5141.98381811059
R63 N015 N008 18562.659793886025
R64 N016 N008 15486.321593209364
R65 N025 N001 24562.72814691567
R66 N026 N001 10186.904078432637
R67 N027 N001 11439.467056609023
R68 N028 N001 36927.47661399813
R69 N029 N001 23903.94263347302
R70 N030 N001 11877.598843045156
R71 N031 N001 32279.81312903194
R72 N032 N001 12859.318496736718
R73 N025 N002 35708.05199953744
R74 N026 N002 14134.584168753723
R75 N027 N002 36679.744265377674
R76 N028 N002 26657.57089527824
R77 N029 N002 10568.20155640463
R78 N030 N002 18478.989439117537
R79 N031 N002 17665.210022044812
R80 N032 N002 18920.52269150747
R81 N025 N003 14086.043029594528
R82 N026 N003 24249.03966938818
R83 N027 N003 16178.56111858329
R84 N028 N003 18904.10367700759
R85 N029 N003 26968.361731054196
R86 N030 N003 16103.824380128828
R87 N031 N003 11427.756213767881
R88 N032 N003 16460.935071516677
R89 N025 N004 10466.177753137392
R90 N026 N004 11630.265547191813
R91 N027 N004 22010.430528403227
R92 N028 N004 25876.591846295298
R93 N029 N004 29283.95567373058
R94 N030 N004 21173.41403781753
R95 N031 N004 13810.478535773933
R96 N032 N004 11918.773935415695
R97 N025 N005 13978.077127845178
R98 N026 N005 13687.337815342127
R99 N027 N005 18344.94251138844
R100 N028 N005 18202.911286883438
R101 N029 N005 12908.71388203408
R102 N030 N005 19482.790736748084
R103 N031 N005 17252.56187168949
R104 N032 N005 23085.730556885686
R105 N025 N006 34183.071103093695
R106 N026 N006 16474.961885327386
R107 N027 N006 11089.99337506648
R108 N028 N006 13605.628543217968
R109 N029 N006 21173.13394923997
R110 N030 N006 16273.518408426153
R111 N031 N006 25360.417094586377
R112 N032 N006 40567.061525225865
R113 N025 N007 10574.097274244841
R114 N026 N007 10542.212119541324
R115 N027 N007 37941.53653707487
R116 N028 N007 18930.740755610015
R117 N029 N007 10735.713603917531
R118 N030 N007 30796.86804721846
R119 N031 N007 10113.985272101605
R120 N032 N007 19497.956107286518
R121 N025 N008 38813.464858753105
R122 N026 N008 14074.58667938754
R123 N027 N008 19417.416840691512
R124 N028 N008 11180.185140838963
R125 N029 N008 22774.70663269992
R126 N030 N008 10178.936944542073
R127 N031 N008 37812.98829948069
R128 N032 N008 31203.547540259817
R129 N009 N033 100000
R130 N010 N034 100000
R131 N011 N035 100000
R132 N012 N036 100000
R133 N013 N037 100000
R134 N014 N038 100000
R135 N015 N039 100000
R136 N016 N040 100000
R137 N025 N033 100000
R138 N026 N034 100000
R139 N027 N035 100000
R140 N028 N036 100000
R141 N029 N037 100000
R142 N030 N038 100000
R143 N031 N039 100000
R144 N032 N040 100000
XU1 0 N001 N999 N998 N009 AD823
XU2 0 N002 N999 N998 N010 AD823
XU3 0 N003 N999 N998 N011 AD823
XU4 0 N004 N999 N998 N012 AD823
XU5 0 N005 N999 N998 N013 AD823
XU6 0 N006 N999 N998 N014 AD823
XU7 0 N007 N999 N998 N015 AD823
XU8 0 N008 N999 N998 N016 AD823
XU9 0 N033 N999 N998 N025 AD823
XU10 0 N034 N999 N998 N026 AD823
XU11 0 N035 N999 N998 N027 AD823
XU12 0 N036 N999 N998 N028 AD823
XU13 0 N037 N999 N998 N029 AD823
XU14 0 N038 N999 N998 N030 AD823
XU15 0 N039 N999 N998 N031 AD823
XU16 0 N040 N999 N998 N032 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 8.692307692307692e-06
I2 0 N002 3.1153846153846153e-06
I3 0 N003 3.0000000000000005e-06
I4 0 N004 7.769230769230771e-06
I5 0 N005 7.923076923076924e-06
I6 0 N006 9.961538461538461e-06
I7 0 N007 1e-05
I8 0 N008 5.980769230769231e-06
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
