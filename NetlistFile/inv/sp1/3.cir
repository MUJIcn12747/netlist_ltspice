* ltspice_circuit_netlist
R1 N009 N001 12894.402818139453
R2 N010 N001 5089.824896228423
R3 N011 N001 5665.059711672082
R4 N012 N001 19849.020726233637
R5 N013 N001 11681.286634919827
R6 N014 N001 5914.096071746268
R7 N015 N001 16445.099674959478
R8 N016 N001 6666.238876837118
R9 N009 N002 16991.422663946232
R10 N010 N002 7056.714798838944
R11 N011 N002 17429.235952309842
R12 N012 N002 12980.526599112463
R13 N013 N002 5196.247500932423
R14 N014 N002 9009.099783706304
R15 N015 N002 8703.884022425316
R16 N016 N002 9234.998796355572
R17 N009 N003 6880.282200413589
R18 N010 N003 11857.980765532026
R19 N011 N003 8103.27253430243
R20 N012 N003 9306.171156537346
R21 N013 N003 13218.56633251121
R22 N014 N003 7791.769447243377
R23 N015 N003 5656.0460686287915
R24 N016 N003 7965.4037182461
R25 N009 N004 5164.160630285567
R26 N010 N004 5856.750208745851
R27 N011 N004 11162.648835822507
R28 N012 N004 12602.908238925147
R29 N013 N004 14033.083878327723
R30 N014 N004 10599.568095837689
R31 N015 N004 6867.708647985135
R32 N016 N004 5923.109596078915
R33 N009 N005 6780.03874484349
R34 N010 N005 6965.46692120691
R35 N011 N005 9164.777587269611
R36 N012 N005 9253.265368341388
R37 N013 N005 6532.579135754797
R38 N014 N005 9686.439021987853
R39 N015 N005 8838.030685564641
R40 N016 N005 11459.101994146593
R41 N009 N006 17451.541911984237
R42 N010 N006 8263.532875359584
R43 N011 N006 5693.421132709144
R44 N012 N006 6883.096395875022
R45 N013 N006 10674.047429355689
R46 N014 N006 8247.341096842243
R47 N015 N006 12704.511581225875
R48 N016 N006 20042.77659110651
R49 N009 N007 5180.433548835668
R50 N010 N007 5424.062176167693
R51 N011 N007 19043.344552134135
R52 N012 N007 9321.74621583706
R53 N013 N007 5304.837380710433
R54 N014 N007 15533.9538019621
R55 N015 N007 5000.0
R56 N016 N007 9538.794604605346
R57 N009 N008 19401.583506424875
R58 N010 N008 6831.017041886885
R59 N011 N008 9532.370783824672
R60 N012 N008 5628.611751860999
R61 N013 N008 12058.779854903558
R62 N014 N008 5132.908313180975
R63 N015 N008 18594.81918802478
R64 N016 N008 15510.175823539466
R65 N025 N001 25777.7835768068
R66 N026 N001 10109.0255196027
R67 N027 N001 11401.730313157675
R68 N028 N001 38203.177978675354
R69 N029 N001 23849.442005271037
R70 N030 N001 12099.457310684205
R71 N031 N001 32842.09637412262
R72 N032 N001 13275.914712791944
R73 N025 N002 35267.15916898191
R74 N026 N002 13790.694344819263
R75 N027 N002 35850.69108815245
R76 N028 N002 26050.262224416736
R77 N029 N002 10388.100558435288
R78 N030 N002 17981.032542860215
R79 N031 N002 17114.166937815764
R80 N032 N002 18871.221970594506
R81 N025 N003 14299.32581162673
R82 N026 N003 23001.34847859029
R83 N027 N003 16493.579624292404
R84 N028 N003 18735.34371221408
R85 N029 N003 27877.71286789802
R86 N030 N003 16068.268269905982
R87 N031 N003 11457.974705291215
R88 N032 N003 16144.013354020744
R89 N025 N004 10247.190378398383
R90 N026 N004 11728.905012279147
R91 N027 N004 22055.279932841815
R92 N028 N004 25750.5424884454
R93 N029 N004 28061.71962210387
R94 N030 N004 21550.941459621565
R95 N031 N004 13927.990423087273
R96 N032 N004 11651.17730021521
R97 N025 N005 13709.202931068856
R98 N026 N005 13833.36309127058
R99 N027 N005 18642.713133193654
R100 N028 N005 18545.24892790423
R101 N029 N005 13342.726163453119
R102 N030 N005 19447.591089300044
R103 N031 N005 17728.285965347444
R104 N032 N005 22380.27892691282
R105 N025 N006 34597.52680591839
R106 N026 N006 16450.973621025027
R107 N027 N006 11295.618290012622
R108 N028 N006 13515.852941297846
R109 N029 N006 22130.85158492117
R110 N030 N006 16913.285029173607
R111 N031 N006 27799.21648026418
R112 N032 N006 41335.03735021765
R113 N025 N007 10443.351438878413
R114 N026 N007 10927.924480194444
R115 N027 N007 36890.51891407012
R116 N028 N007 18911.11958306127
R117 N029 N007 10500.376344333885
R118 N030 N007 29537.20650481169
R119 N031 N007 9808.999063529369
R120 N032 N007 19134.228267067592
R121 N025 N008 38807.40010598999
R122 N026 N008 13707.99143708485
R123 N027 N008 18310.839787536643
R124 N028 N008 11304.0143085179
R125 N029 N008 23341.69682427555
R126 N030 N008 10316.67473226172
R127 N031 N008 38995.833162356445
R128 N032 N008 32911.83381288545
R129 N009 N033 100000
R130 N010 N034 100000
R131 N011 N035 100000
R132 N012 N036 100000
R133 N013 N037 100000
R134 N014 N038 100000
R135 N015 N039 100000
R136 N016 N040 100000
R137 N025 N033 100000
R138 N026 N034 100000
R139 N027 N035 100000
R140 N028 N036 100000
R141 N029 N037 100000
R142 N030 N038 100000
R143 N031 N039 100000
R144 N032 N040 100000
XU1 0 N001 N999 N998 N009 AD823
XU2 0 N002 N999 N998 N010 AD823
XU3 0 N003 N999 N998 N011 AD823
XU4 0 N004 N999 N998 N012 AD823
XU5 0 N005 N999 N998 N013 AD823
XU6 0 N006 N999 N998 N014 AD823
XU7 0 N007 N999 N998 N015 AD823
XU8 0 N008 N999 N998 N016 AD823
XU9 0 N033 N999 N998 N025 AD823
XU10 0 N034 N999 N998 N026 AD823
XU11 0 N035 N999 N998 N027 AD823
XU12 0 N036 N999 N998 N028 AD823
XU13 0 N037 N999 N998 N029 AD823
XU14 0 N038 N999 N998 N030 AD823
XU15 0 N039 N999 N998 N031 AD823
XU16 0 N040 N999 N998 N032 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 1e-05
I2 0 N002 1.7335058214747739e-06
I3 0 N003 9.197930142302717e-06
I4 0 N004 5.0970245795601556e-06
I5 0 N005 5.847347994825356e-06
I6 0 N006 1.9016817593790427e-06
I7 0 N007 2.2509702457956016e-06
I8 0 N008 9.741267787839587e-06
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
