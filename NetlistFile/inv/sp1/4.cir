* ltspice_circuit_netlist
R1 N009 N001 12613.42576529059
R2 N010 N001 5088.318207927589
R3 N011 N001 5743.146671522434
R4 N012 N001 20002.860961331186
R5 N013 N001 11810.889402098168
R6 N014 N001 5935.251640281872
R7 N015 N001 16650.01090724098
R8 N016 N001 6581.9645294690845
R9 N009 N002 16881.988849442285
R10 N010 N002 6891.405699177926
R11 N011 N002 17308.009903956936
R12 N012 N002 12488.023979118718
R13 N013 N002 5227.037305598375
R14 N014 N002 9148.797002536645
R15 N015 N002 8597.734506755607
R16 N016 N002 9365.097178314383
R17 N009 N003 6995.732458520892
R18 N010 N003 11929.46895029453
R19 N011 N003 8279.427938653916
R20 N012 N003 9266.432344498464
R21 N013 N003 13385.097958266751
R22 N014 N003 7923.714074198721
R23 N015 N003 5748.569367317204
R24 N016 N003 8128.700880904927
R25 N009 N004 5222.265314147483
R26 N010 N004 5812.888089333837
R27 N011 N004 11109.65501574185
R28 N012 N004 12827.700001632586
R29 N013 N004 14106.942688006584
R30 N014 N004 10592.308994289508
R31 N015 N004 6951.204729340229
R32 N016 N004 5969.920478766676
R33 N009 N005 6756.870133760203
R34 N010 N005 6877.190238772315
R35 N011 N005 9426.004101219874
R36 N012 N005 9174.509063414405
R37 N013 N005 6491.07086848963
R38 N014 N005 9782.265419068415
R39 N015 N005 8844.647658065678
R40 N016 N005 11461.51939853046
R41 N009 N006 17167.52107318012
R42 N010 N006 8297.49601778345
R43 N011 N006 5708.841389503896
R44 N012 N006 6884.649564464583
R45 N013 N006 10924.53988721341
R46 N014 N006 8256.272091426817
R47 N015 N006 12754.527442906707
R48 N016 N006 19687.69612282076
R49 N009 N007 5263.373219147749
R50 N010 N007 5357.024590800705
R51 N011 N007 18697.116889082878
R52 N012 N007 9108.013244749407
R53 N013 N007 5318.724865341251
R54 N014 N007 15333.2444659567
R55 N015 N007 5023.674414614917
R56 N016 N007 9624.499447863687
R57 N009 N008 19217.79451101951
R58 N010 N008 6782.022998272027
R59 N011 N008 9587.740495958615
R60 N012 N008 5624.503926958629
R61 N013 N008 11659.045406108484
R62 N014 N008 5154.164158287872
R63 N015 N008 18810.93291769744
R64 N016 N008 15768.838062635135
R65 N025 N001 26941.289661855426
R66 N026 N001 10218.975864507758
R67 N027 N001 11382.569827914542
R68 N028 N001 40384.275042975416
R69 N029 N001 23621.530893507905
R70 N030 N001 12070.622039210875
R71 N031 N001 32087.353334776468
R72 N032 N001 13243.370423873166
R73 N025 N002 33639.30432716727
R74 N026 N002 13886.56946644802
R75 N027 N002 35941.29338330412
R76 N028 N002 25890.04502386881
R77 N029 N002 10579.42660473067
R78 N030 N002 17777.79482053138
R79 N031 N002 17204.029430941326
R80 N032 N002 18847.28468549209
R81 N025 N003 13844.465120607429
R82 N026 N003 23385.10192901236
R83 N027 N003 16342.148313478703
R84 N028 N003 18116.20354760927
R85 N029 N003 25674.15473500029
R86 N030 N003 15758.443682167373
R87 N031 N003 11624.008804990528
R88 N032 N003 15960.070358814144
R89 N025 N004 10242.266346866976
R90 N026 N004 11674.527511400902
R91 N027 N004 21178.525863108305
R92 N028 N004 25351.191049222518
R93 N029 N004 28296.233570918528
R94 N030 N004 21112.79129996207
R95 N031 N004 13962.314441864324
R96 N032 N004 12103.415727783526
R97 N025 N005 13922.071682190928
R98 N026 N005 13766.509468790455
R99 N027 N005 18907.877990809608
R100 N028 N005 18397.59823116596
R101 N029 N005 12944.480052655006
R102 N030 N005 19216.403711129427
R103 N031 N005 17448.13071642053
R104 N032 N005 23292.908760052782
R105 N025 N006 33316.44185896921
R106 N026 N006 16528.77101750309
R107 N027 N006 11396.452843073006
R108 N028 N006 13620.977876031486
R109 N029 N006 20834.376475619323
R110 N030 N006 16782.033495164564
R111 N031 N006 26594.070328113314
R112 N032 N006 40490.60510869547
R113 N025 N007 10373.906458165691
R114 N026 N007 10657.701666909416
R115 N027 N007 36456.10457375783
R116 N028 N007 18633.698752095886
R117 N029 N007 10644.00482707198
R118 N030 N007 30853.70744798006
R119 N031 N007 10126.0468584082
R120 N032 N007 19351.410786715416
R121 N025 N008 42943.54747707285
R122 N026 N008 13956.52866696845
R123 N027 N008 18957.767070281843
R124 N028 N008 11436.73178444356
R125 N029 N008 23911.484734389545
R126 N030 N008 10149.42484332836
R127 N031 N008 35151.4813658951
R128 N032 N008 30230.889068043667
R129 N009 N033 100000
R130 N010 N034 100000
R131 N011 N035 100000
R132 N012 N036 100000
R133 N013 N037 100000
R134 N014 N038 100000
R135 N015 N039 100000
R136 N016 N040 100000
R137 N025 N033 100000
R138 N026 N034 100000
R139 N027 N035 100000
R140 N028 N036 100000
R141 N029 N037 100000
R142 N030 N038 100000
R143 N031 N039 100000
R144 N032 N040 100000
XU1 0 N001 N999 N998 N009 AD823
XU2 0 N002 N999 N998 N010 AD823
XU3 0 N003 N999 N998 N011 AD823
XU4 0 N004 N999 N998 N012 AD823
XU5 0 N005 N999 N998 N013 AD823
XU6 0 N006 N999 N998 N014 AD823
XU7 0 N007 N999 N998 N015 AD823
XU8 0 N008 N999 N998 N016 AD823
XU9 0 N033 N999 N998 N025 AD823
XU10 0 N034 N999 N998 N026 AD823
XU11 0 N035 N999 N998 N027 AD823
XU12 0 N036 N999 N998 N028 AD823
XU13 0 N037 N999 N998 N029 AD823
XU14 0 N038 N999 N998 N030 AD823
XU15 0 N039 N999 N998 N031 AD823
XU16 0 N040 N999 N998 N032 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 3.291995490417137e-06
I2 0 N002 3.618940248027058e-06
I3 0 N003 3.3821871476888394e-06
I4 0 N004 3.2581736189402487e-06
I5 0 N005 1e-05
I6 0 N006 2.5930101465614432e-06
I7 0 N007 1.8151071025930104e-06
I8 0 N008 4.498308906426157e-06
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
