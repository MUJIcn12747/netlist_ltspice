* ltspice_circuit_netlist
R1 N009 N001 12663.831362240455
R2 N010 N001 5087.088365722843
R3 N011 N001 5724.412732328887
R4 N012 N001 18878.33163385366
R5 N013 N001 11594.59383075058
R6 N014 N001 5964.187645268792
R7 N015 N001 16693.758913822046
R8 N016 N001 6588.025683339273
R9 N009 N002 17356.13571247758
R10 N010 N002 6965.648598135727
R11 N011 N002 17268.3720617182
R12 N012 N002 12985.65774169691
R13 N013 N002 5227.514026777323
R14 N014 N002 8955.956761715026
R15 N015 N002 8783.742050919705
R16 N016 N002 9264.696777336043
R17 N009 N003 6983.8682223858
R18 N010 N003 11944.081922671437
R19 N011 N003 8315.221870353122
R20 N012 N003 9264.350540267058
R21 N013 N003 13642.696844807102
R22 N014 N003 7874.882721702608
R23 N015 N003 5771.0786423125965
R24 N016 N003 8068.333813471973
R25 N009 N004 5184.167842156131
R26 N010 N004 5812.001632690506
R27 N011 N004 10846.112132756072
R28 N012 N004 12683.26998037912
R29 N013 N004 14246.262662588255
R30 N014 N004 10648.131621140212
R31 N015 N004 7083.552910034203
R32 N016 N004 5878.221519410394
R33 N009 N005 6888.555635208282
R34 N010 N005 6950.399063050038
R35 N011 N005 9194.998303462966
R36 N012 N005 9338.50567875171
R37 N013 N005 6567.598011147606
R38 N014 N005 9752.93793923723
R39 N015 N005 9076.127327409065
R40 N016 N005 11234.974544654142
R41 N009 N006 17502.091973084873
R42 N010 N006 8281.944535501802
R43 N011 N006 5679.813349017297
R44 N012 N006 6783.431452324832
R45 N013 N006 10889.824742031686
R46 N014 N006 8248.27624951655
R47 N015 N006 12649.522750785656
R48 N016 N006 20047.80460337742
R49 N009 N007 5246.685163040159
R50 N010 N007 5399.180033588117
R51 N011 N007 19619.486450680837
R52 N012 N007 9127.928347744031
R53 N013 N007 5355.423199914916
R54 N014 N007 15487.834128387618
R55 N015 N007 5000.0
R56 N016 N007 9790.126354415659
R57 N009 N008 19481.563553639913
R58 N010 N008 6856.906325575666
R59 N011 N008 9693.29133823122
R60 N012 N008 5674.514686232702
R61 N013 N008 11879.087033723245
R62 N014 N008 5138.476296067733
R63 N015 N008 18861.0676482218
R64 N016 N008 15636.009259895929
R65 N025 N001 26396.231064895645
R66 N026 N001 10182.309192476347
R67 N027 N001 11434.950531799863
R68 N028 N001 39273.60150140879
R69 N029 N001 23319.721536359426
R70 N030 N001 11726.499153393803
R71 N031 N001 32164.64960400094
R72 N032 N001 13637.791906830362
R73 N025 N002 34388.59002436929
R74 N026 N002 14090.352922857686
R75 N027 N002 33793.897452076504
R76 N028 N002 25688.3907386593
R77 N029 N002 10390.443974204796
R78 N030 N002 18324.548299664802
R79 N031 N002 17998.525087597292
R80 N032 N002 18656.26655535768
R81 N025 N003 14061.470912249342
R82 N026 N003 24108.864808909184
R83 N027 N003 16343.47138638558
R84 N028 N003 19046.6082154834
R85 N029 N003 28545.38064995322
R86 N030 N003 15786.566605360968
R87 N031 N003 11273.611622345717
R88 N032 N003 16225.191196035139
R89 N025 N004 10363.651717411289
R90 N026 N004 11520.502519815613
R91 N027 N004 22168.20258843821
R92 N028 N004 25601.221052737732
R93 N029 N004 29630.49519386799
R94 N030 N004 20989.072545649113
R95 N031 N004 13605.98502290152
R96 N032 N004 11848.61195052309
R97 N025 N005 13787.779459913017
R98 N026 N005 13664.543880759282
R99 N027 N005 18657.49408618052
R100 N028 N005 18191.820343079777
R101 N029 N005 13129.606069686233
R102 N030 N005 19193.913693385035
R103 N031 N005 17501.21462546573
R104 N032 N005 22473.138555905134
R105 N025 N006 35361.88035831875
R106 N026 N006 16629.17887443103
R107 N027 N006 11294.283133973122
R108 N028 N006 13602.908132368053
R109 N029 N006 21735.778415437522
R110 N030 N006 16154.524853429994
R111 N031 N006 25269.244311701932
R112 N032 N006 37112.15383615212
R113 N025 N007 10466.451703773086
R114 N026 N007 10746.9107924677
R115 N027 N007 37870.328183085956
R116 N028 N007 18454.18351404676
R117 N029 N007 10557.04361370313
R118 N030 N007 32914.644725579485
R119 N031 N007 10011.823156292456
R120 N032 N007 18714.180099519963
R121 N025 N008 37177.2744973372
R122 N026 N008 14098.175835550446
R123 N027 N008 19052.28264811902
R124 N028 N008 11428.761510552695
R125 N029 N008 24472.236372912277
R126 N030 N008 10304.957108683866
R127 N031 N008 34960.06529045251
R128 N032 N008 32406.55145457508
R129 N009 N033 100000
R130 N010 N034 100000
R131 N011 N035 100000
R132 N012 N036 100000
R133 N013 N037 100000
R134 N014 N038 100000
R135 N015 N039 100000
R136 N016 N040 100000
R137 N025 N033 100000
R138 N026 N034 100000
R139 N027 N035 100000
R140 N028 N036 100000
R141 N029 N037 100000
R142 N030 N038 100000
R143 N031 N039 100000
R144 N032 N040 100000
XU1 0 N001 N999 N998 N009 AD823
XU2 0 N002 N999 N998 N010 AD823
XU3 0 N003 N999 N998 N011 AD823
XU4 0 N004 N999 N998 N012 AD823
XU5 0 N005 N999 N998 N013 AD823
XU6 0 N006 N999 N998 N014 AD823
XU7 0 N007 N999 N998 N015 AD823
XU8 0 N008 N999 N998 N016 AD823
XU9 0 N033 N999 N998 N025 AD823
XU10 0 N034 N999 N998 N026 AD823
XU11 0 N035 N999 N998 N027 AD823
XU12 0 N036 N999 N998 N028 AD823
XU13 0 N037 N999 N998 N029 AD823
XU14 0 N038 N999 N998 N030 AD823
XU15 0 N039 N999 N998 N031 AD823
XU16 0 N040 N999 N998 N032 AD823
V999 N999 0 5 Rser=0
V998 0 N998 5 Rser=0
I1 0 N001 7.587168758716877e-06
I2 0 N002 6.290097629009763e-06
I3 0 N003 2.6080892608089267e-06
I4 0 N004 4.337517433751744e-06
I5 0 N005 9.246861924686193e-06
I6 0 N006 1e-05
I7 0 N007 7.92189679218968e-06
I8 0 N008 2.1059972105997214e-06
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
