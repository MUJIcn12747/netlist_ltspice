* ltspice_circuit_netlist
R73 0 N001 31298.83090649244
R74 0 N002 3841.491072248526
R75 0 N003 32987.77834692018
R76 0 N004 3640.9056327526396
R77 0 N005 31570.4809969361
R78 0 N006 3493.431070648044
R79 0 N007 29793.17345661624
R80 0 N008 3333.3333333333335
R81 0 N009 32402.650006134536
R82 0 N010 3976.775494874754
R83 0 N011 33661.02741242892
R84 0 N012 4162.930172497457
R1 N001 N019 16731.643110382058
R37 N002 N019 24086.67031532982
R2 N001 N020 14055.712013873164
R38 N002 N020 21465.58156074654
R3 N001 N021 13210.837848249932
R39 N002 N021 21693.60624171649
R4 N001 N022 20713.02206831117
R40 N002 N022 30098.832516980077
R5 N001 N023 18281.14089907079
R41 N002 N023 25714.898174132824
R6 N001 N024 15457.291028554997
R42 N002 N024 23593.117908333537
R7 N003 N019 12000.883617261532
R43 N004 N019 19393.1967683293
R8 N003 N020 11259.206537852584
R44 N004 N020 18876.54642652394
R9 N003 N021 12845.380277036276
R45 N004 N021 20683.061897316777
R10 N003 N022 15388.392667360924
R46 N004 N022 23044.015272497018
R11 N003 N023 20267.368553602948
R47 N004 N023 29500.3159495057
R12 N003 N024 20013.61860751386
R48 N004 N024 28214.360769710387
R13 N005 N019 15304.83146996651
R49 N006 N019 23516.932255466418
R14 N005 N020 21658.832706084588
R50 N006 N020 29433.4128551249
R15 N005 N021 12517.28760821117
R51 N006 N021 20173.56146127463
R16 N005 N022 13186.344748287254
R52 N006 N022 22176.182475010508
R17 N005 N023 14985.118261540334
R53 N006 N023 22490.913432239333
R18 N005 N024 10567.89749815846
R54 N006 N024 17491.688430978356
R19 N007 N019 14785.112434210507
R55 N008 N019 22994.29860677564
R20 N007 N020 17025.97681956436
R56 N008 N020 26734.52538685603
R21 N007 N021 11535.039387698784
R57 N008 N021 18246.617383216697
R22 N007 N022 11008.700640466765
R58 N008 N022 18821.207099040883
R23 N007 N023 12284.106238160573
R59 N008 N023 19784.818373008755
R24 N007 N024 13363.610861579997
R60 N008 N024 20642.321934769894
R25 N009 N019 12726.66501854623
R61 N010 N019 20038.673835293546
R26 N009 N020 16235.871133150988
R62 N010 N020 24632.181829192345
R27 N009 N021 23953.001594933947
R63 N010 N021 31251.808802117164
R28 N009 N022 19450.35753218183
R64 N010 N022 29678.686505483663
R29 N009 N023 12337.763658532223
R65 N010 N023 19600.75526246676
R30 N009 N024 22414.91482017412
R66 N010 N024 31139.874228202243
R31 N011 N019 12478.74345064769
R67 N012 N019 19877.923876647004
R32 N011 N020 22160.911242145372
R68 N012 N020 30407.739138646048
R33 N011 N021 20535.97396155852
R69 N012 N021 28768.631904242644
R34 N011 N022 21323.760356066985
R70 N012 N022 30016.36076501344
R35 N011 N023 18074.33633814253
R71 N012 N023 27329.80153841027
R36 N011 N024 15161.138695596826
R72 N012 N024 23756.84705729982
R85 N001 N013 10000
R86 N003 N014 10000
R87 N005 N015 10000
R88 N007 N016 10000
R89 N009 N017 10000
R90 N011 N018 10000
XU1 N002 N001 N999 N998 N013 AD8606
XU2 N004 N003 N999 N998 N014 AD8606
XU3 N006 N005 N999 N998 N015 AD8606
XU4 N008 N007 N999 N998 N016 AD8606
XU5 N010 N009 N999 N998 N017 AD8606
XU6 N012 N011 N999 N998 N018 AD8606
V1 N019 0 0.12158808933002482 Rser=0
V2 N020 0 0.10918114143920596 Rser=0
V3 N021 0 0.14888337468982632 Rser=0
V4 N022 0 0.16401985111662531 Rser=0
V5 N023 0 0.15508684863523572 Rser=0
V6 N024 0 0.2 Rser=0
V999 N999 0 3 Rser=0
V998 0 N998 3 Rser=0
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
