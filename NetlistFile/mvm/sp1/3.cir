* ltspice_circuit_netlist
R73 0 N001 32246.6553312782
R74 0 N002 3874.9064880681467
R75 0 N003 32430.300972631434
R76 0 N004 3636.0258057835413
R77 0 N005 31003.511947192474
R78 0 N006 3483.2460106775025
R79 0 N007 33368.95613221514
R80 0 N008 3333.3333333333335
R81 0 N009 32003.52495445458
R82 0 N010 3984.1879693498945
R83 0 N011 31112.847499892272
R84 0 N012 4151.411500088614
R1 N001 N019 16410.389979696807
R37 N002 N019 25064.634174379506
R2 N001 N020 13711.826436915608
R38 N002 N020 22200.491791582546
R3 N001 N021 13540.588070677337
R39 N002 N021 21703.032982062072
R4 N001 N022 21204.640161888576
R40 N002 N022 27596.41623834682
R5 N001 N023 18058.10432518206
R41 N002 N023 26692.17105552468
R6 N001 N024 15585.51179600717
R42 N002 N024 24272.38997845806
R7 N003 N019 11810.482194474058
R43 N004 N019 19243.280638036515
R8 N003 N020 11357.77899666881
R44 N004 N020 18760.691080493594
R9 N003 N021 12995.971011330095
R45 N004 N021 20788.495357138912
R10 N003 N022 15451.370797952739
R46 N004 N022 24876.32524094667
R11 N003 N023 21273.283167150268
R47 N004 N023 29191.53440759215
R12 N003 N024 20841.347857306748
R48 N004 N024 31012.268046140263
R13 N005 N019 15463.319533139696
R49 N006 N019 23350.556729012915
R14 N005 N020 20632.617373793346
R50 N006 N020 29440.702391487976
R15 N005 N021 12716.071584596442
R51 N006 N021 20145.558765151523
R16 N005 N022 13281.217680919373
R52 N006 N022 21001.43966255168
R17 N005 N023 15480.770142061516
R53 N006 N023 23885.416088473463
R18 N005 N024 10578.38257384968
R54 N006 N024 17529.381046086684
R19 N007 N019 15065.818270973541
R55 N008 N019 22910.687937634462
R20 N007 N020 18085.49624858957
R56 N008 N020 26047.365327644427
R21 N007 N021 11176.858523241233
R57 N008 N021 19251.82574182472
R22 N007 N022 11280.853209635487
R58 N008 N022 18442.775213759338
R23 N007 N023 12200.821501496
R59 N008 N023 19964.745886452
R24 N007 N024 13220.868043862389
R60 N008 N024 20626.878378364894
R25 N009 N019 12869.165576596431
R61 N010 N019 20489.87491016899
R26 N009 N020 15859.719804352673
R62 N010 N020 23843.269022051303
R27 N009 N021 23459.137117171245
R63 N010 N021 33929.03890835679
R28 N009 N022 19858.493815323985
R64 N010 N022 27942.3282154795
R29 N009 N023 12288.967035205455
R65 N010 N023 19067.088180609844
R30 N009 N024 22215.14176172607
R66 N010 N024 30606.542596276766
R31 N011 N019 12756.488104178155
R67 N012 N019 19766.701442370046
R32 N011 N020 23369.5438660658
R68 N012 N020 31363.59967816281
R33 N011 N021 21303.508547472946
R69 N012 N021 28514.75082736007
R34 N011 N022 22065.363336452665
R70 N012 N022 30052.607037942376
R35 N011 N023 17707.054665192147
R71 N012 N023 26916.15459066018
R36 N011 N024 16230.841362867977
R72 N012 N024 23966.005524198248
R85 N001 N013 10000
R86 N003 N014 10000
R87 N005 N015 10000
R88 N007 N016 10000
R89 N009 N017 10000
R90 N011 N018 10000
XU1 N002 N001 N999 N998 N013 AD8606
XU2 N004 N003 N999 N998 N014 AD8606
XU3 N006 N005 N999 N998 N015 AD8606
XU4 N008 N007 N999 N998 N016 AD8606
XU5 N010 N009 N999 N998 N017 AD8606
XU6 N012 N011 N999 N998 N018 AD8606
V1 N019 0 0.15819774718398 Rser=0
V2 N020 0 0.2 Rser=0
V3 N021 0 0.061326658322903634 Rser=0
V4 N022 0 0.19249061326658326 Rser=0
V5 N023 0 0.11614518147684605 Rser=0
V6 N024 0 0.14768460575719652 Rser=0
V999 N999 0 3 Rser=0
V998 0 N998 3 Rser=0
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
