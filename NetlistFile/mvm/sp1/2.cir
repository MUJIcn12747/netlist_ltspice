* ltspice_circuit_netlist
R73 0 N001 32202.956504945454
R74 0 N002 3851.0782994090214
R75 0 N003 31306.335903758663
R76 0 N004 3614.4487576224396
R77 0 N005 32105.91127558086
R78 0 N006 3495.950107100165
R79 0 N007 34353.40243714522
R80 0 N008 3333.3333333333335
R81 0 N009 34457.20897024395
R82 0 N010 3980.2326794103487
R83 0 N011 32420.656078323354
R84 0 N012 4154.555613825673
R1 N001 N019 16168.894609690225
R37 N002 N019 25096.76011901642
R2 N001 N020 13947.17437867365
R38 N002 N020 21355.115133484887
R3 N001 N021 13645.697885929292
R39 N002 N021 20746.104663942908
R4 N001 N022 21492.131617223105
R40 N002 N022 30393.12883129566
R5 N001 N023 18035.274062316137
R41 N002 N023 26369.546402278167
R6 N001 N024 15343.768248482025
R42 N002 N024 22986.90046215485
R7 N003 N019 11756.255191583574
R43 N004 N019 19852.716628551123
R8 N003 N020 11200.01986092695
R44 N004 N020 18343.425203433882
R9 N003 N021 13044.27998454306
R45 N004 N021 21349.410186650413
R10 N003 N022 15426.903828045735
R46 N004 N022 23917.16593250359
R11 N003 N023 21524.744102731824
R47 N004 N023 28030.71630611466
R12 N003 N024 21049.410466710302
R48 N004 N024 29098.706263310956
R13 N005 N019 14692.778890946205
R49 N006 N019 23457.528448640558
R14 N005 N020 20911.401505660528
R50 N006 N020 27509.30504538395
R15 N005 N021 12666.391962576832
R51 N006 N021 20049.066824471854
R16 N005 N022 13281.996182392613
R52 N006 N022 20798.148595571725
R17 N005 N023 15342.77706671798
R53 N006 N023 23675.17656014897
R18 N005 N024 10457.273262765197
R54 N006 N024 17079.20634703334
R19 N007 N019 14702.532793315355
R55 N008 N019 22612.485245375792
R20 N007 N020 17778.14406951686
R56 N008 N020 27347.71892793401
R21 N007 N021 11379.593948263357
R57 N008 N021 19268.714257529038
R22 N007 N022 11094.380075532785
R58 N008 N022 18165.778511064094
R23 N007 N023 12250.821385664753
R59 N008 N023 20798.967373386775
R24 N007 N024 13525.95422768272
R60 N008 N024 21976.614500434353
R25 N009 N019 12555.514569383833
R61 N010 N019 20120.393906709523
R26 N009 N020 16026.94297326471
R62 N010 N020 24912.86889541271
R27 N009 N021 23143.926056292068
R63 N010 N021 32872.01873490281
R28 N009 N022 19215.92615908964
R64 N010 N022 27743.55826147913
R29 N009 N023 12415.925266623124
R65 N010 N023 19767.879223240514
R30 N009 N024 23327.449964233227
R66 N010 N024 29643.095703672123
R31 N011 N019 12554.043373903332
R67 N012 N019 19876.528881275564
R32 N011 N020 22713.464311755015
R68 N012 N020 30804.211908676312
R33 N011 N021 21182.572149996973
R69 N012 N021 28268.91620479157
R34 N011 N022 21533.546942777226
R70 N012 N022 29417.36876724117
R35 N011 N023 17792.550967328018
R71 N012 N023 26680.881528349677
R36 N011 N024 16114.594050757738
R72 N012 N024 23861.007611752964
R85 N001 N013 10000
R86 N003 N014 10000
R87 N005 N015 10000
R88 N007 N016 10000
R89 N009 N017 10000
R90 N011 N018 10000
XU1 N002 N001 N999 N998 N013 AD8606
XU2 N004 N003 N999 N998 N014 AD8606
XU3 N006 N005 N999 N998 N015 AD8606
XU4 N008 N007 N999 N998 N016 AD8606
XU5 N010 N009 N999 N998 N017 AD8606
XU6 N012 N011 N999 N998 N018 AD8606
V1 N019 0 0.14754098360655737 Rser=0
V2 N020 0 0.2 Rser=0
V3 N021 0 0.15535939470365703 Rser=0
V4 N022 0 0.10567465321563684 Rser=0
V5 N023 0 0.10063051702395966 Rser=0
V6 N024 0 0.09558638083228248 Rser=0
V999 N999 0 3 Rser=0
V998 0 N998 3 Rser=0
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
