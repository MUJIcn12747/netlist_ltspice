* ltspice_circuit_netlist
R73 0 N001 32298.6920095354
R74 0 N002 3848.7944875643534
R75 0 N003 32457.456262618885
R76 0 N004 3662.8478763146627
R77 0 N005 32094.304946304197
R78 0 N006 3499.3620145572413
R79 0 N007 30968.54888707713
R80 0 N008 3342.222379234624
R81 0 N009 33537.75642905823
R82 0 N010 3978.449140676179
R83 0 N011 33102.9173482196
R84 0 N012 4129.860749167503
R1 N001 N019 16654.25249296321
R37 N002 N019 24651.583693994868
R2 N001 N020 13649.902394906052
R38 N002 N020 21936.13830227506
R3 N001 N021 13616.665331806313
R39 N002 N021 20563.516580436317
R4 N001 N022 20076.76015850467
R40 N002 N022 29346.144676043383
R5 N001 N023 17714.970127005337
R41 N002 N023 26598.20080815904
R6 N001 N024 15412.38129520868
R42 N002 N024 23805.45213766065
R7 N003 N019 12099.649582994129
R43 N004 N019 19041.29255564896
R8 N003 N020 11395.00297409724
R44 N004 N020 18538.80965215868
R9 N003 N021 12819.88366904356
R45 N004 N021 20543.638613934985
R10 N003 N022 15302.519027930664
R46 N004 N022 23420.609395631236
R11 N003 N023 20539.110323715075
R47 N004 N023 28855.91635700676
R12 N003 N024 20754.28648161386
R48 N004 N024 29333.52441953682
R13 N005 N019 15096.429253886086
R49 N006 N019 22030.341770055536
R14 N005 N020 21188.124160224805
R50 N006 N020 28833.606863924655
R15 N005 N021 12724.841490603361
R51 N006 N021 21122.939731552247
R16 N005 N022 13067.836123485993
R52 N006 N022 20806.443421558975
R17 N005 N023 15313.20758389671
R53 N006 N023 23651.558603829024
R18 N005 N024 10796.844183520418
R54 N006 N024 17154.619377577237
R19 N007 N019 14955.451160011951
R55 N008 N019 23006.86302757836
R20 N007 N020 17695.817583337423
R56 N008 N020 26757.118578503392
R21 N007 N021 11313.857199912965
R57 N008 N021 18367.062200095195
R22 N007 N022 11068.68324399084
R58 N008 N022 18227.640677133197
R23 N007 N023 12410.975396353004
R59 N008 N023 19808.958361446537
R24 N007 N024 13641.118799231317
R60 N008 N024 22146.5882832373
R25 N009 N019 12709.437242311422
R61 N010 N019 20083.444870473602
R26 N009 N020 15862.54817340188
R62 N010 N020 24528.74978221932
R27 N009 N021 23376.8659588282
R63 N010 N021 32180.914870081062
R28 N009 N022 19536.051525575665
R64 N010 N022 28641.564360562355
R29 N009 N023 12225.659843697767
R65 N010 N023 19256.27768227745
R30 N009 N024 22754.10255480004
R66 N010 N024 31416.549779104178
R31 N011 N019 12645.930409752942
R67 N012 N019 20161.557932914093
R32 N011 N020 22549.110858453732
R68 N012 N020 31115.6840097955
R33 N011 N021 21281.67164912377
R69 N012 N021 30357.690925548988
R34 N011 N022 21258.753292867794
R70 N012 N022 29951.054024938458
R35 N011 N023 17496.96809818279
R71 N012 N023 25381.50351414564
R36 N011 N024 16039.978985648264
R72 N012 N024 24586.104808974487
R85 N001 N013 10000
R86 N003 N014 10000
R87 N005 N015 10000
R88 N007 N016 10000
R89 N009 N017 10000
R90 N011 N018 10000
XU1 N002 N001 N999 N998 N013 AD8606
XU2 N004 N003 N999 N998 N014 AD8606
XU3 N006 N005 N999 N998 N015 AD8606
XU4 N008 N007 N999 N998 N016 AD8606
XU5 N010 N009 N999 N998 N017 AD8606
XU6 N012 N011 N999 N998 N018 AD8606
V1 N019 0 0.11335578002244669 Rser=0
V2 N020 0 0.13580246913580246 Rser=0
V3 N021 0 0.2 Rser=0
V4 N022 0 0.041750841750841754 Rser=0
V5 N023 0 0.05656565656565656 Rser=0
V6 N024 0 0.1048260381593715 Rser=0
V999 N999 0 3 Rser=0
V998 0 N998 3 Rser=0
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
