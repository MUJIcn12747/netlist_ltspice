* ltspice_circuit_netlist
R73 0 N001 31553.9939490551
R74 0 N002 3895.0242621872153
R75 0 N003 31404.73129006166
R76 0 N004 3618.6690533277415
R77 0 N005 31946.094621459943
R78 0 N006 3485.8008565903556
R79 0 N007 33031.8172120118
R80 0 N008 3333.3333333333335
R81 0 N009 31004.077800591036
R82 0 N010 3949.0507592681906
R83 0 N011 30352.625056224704
R84 0 N012 4190.161426384532
R1 N001 N019 16433.163824293955
R37 N002 N019 24652.301026417725
R2 N001 N020 13831.175939623456
R38 N002 N020 22011.069542743797
R3 N001 N021 13909.680592241051
R39 N002 N021 21311.116052204892
R4 N001 N022 20631.29465302502
R40 N002 N022 26998.90523721065
R5 N001 N023 18778.477187721208
R41 N002 N023 27114.106796400065
R6 N001 N024 15741.610487660862
R42 N002 N024 23860.937979106686
R7 N003 N019 11959.401613863629
R43 N004 N019 19269.320765492143
R8 N003 N020 11194.95381041519
R44 N004 N020 18425.293273315034
R9 N003 N021 13093.191561400487
R45 N004 N021 20241.479784625713
R10 N003 N022 15457.534845377682
R46 N004 N022 24006.887120798663
R11 N003 N023 20493.163633891978
R47 N004 N023 28969.60175272639
R12 N003 N024 20569.612855156796
R48 N004 N024 29645.27068163502
R13 N005 N019 14833.03878355428
R49 N006 N019 22519.94914747846
R14 N005 N020 21610.33362050846
R50 N006 N020 29344.641078400855
R15 N005 N021 12332.068064058507
R51 N006 N021 20579.920939534797
R16 N005 N022 13026.456329467277
R52 N006 N022 21761.1712108541
R17 N005 N023 15073.49190523186
R53 N006 N023 23791.456251422554
R18 N005 N024 10509.799673747593
R54 N006 N024 17865.294624753933
R19 N007 N019 14766.747737842355
R55 N008 N019 23851.924769549285
R20 N007 N020 17530.78451087577
R56 N008 N020 25841.726268633818
R21 N007 N021 11368.737859618297
R57 N008 N021 18177.980719415445
R22 N007 N022 11283.585515712928
R58 N008 N022 18684.053962270445
R23 N007 N023 12201.116468502472
R59 N008 N023 20147.976709179467
R24 N007 N024 13363.507698595351
R60 N008 N024 21010.943622163053
R25 N009 N019 12639.04144895482
R61 N010 N019 20388.175077096294
R26 N009 N020 15552.690786576859
R62 N010 N020 23848.39675024731
R27 N009 N021 23477.708320843227
R63 N010 N021 33405.55760851528
R28 N009 N022 19446.92835940376
R64 N010 N022 28731.840725722093
R29 N009 N023 12311.361013837924
R65 N010 N023 19236.652054355916
R30 N009 N024 22603.7235970749
R66 N010 N024 30277.495488035962
R31 N011 N019 12598.666383431837
R67 N012 N019 20257.335602914678
R32 N011 N020 22014.080021102098
R68 N012 N020 29660.637001859737
R33 N011 N021 21088.113682382627
R69 N012 N021 28717.39430491971
R34 N011 N022 21430.02442338335
R70 N012 N022 28584.196771825456
R35 N011 N023 17616.528666106107
R71 N012 N023 25287.25150975432
R36 N011 N024 15822.484922317259
R72 N012 N024 24498.07127241933
R85 N001 N013 10000
R86 N003 N014 10000
R87 N005 N015 10000
R88 N007 N016 10000
R89 N009 N017 10000
R90 N011 N018 10000
XU1 N002 N001 N999 N998 N013 AD8606
XU2 N004 N003 N999 N998 N014 AD8606
XU3 N006 N005 N999 N998 N015 AD8606
XU4 N008 N007 N999 N998 N016 AD8606
XU5 N010 N009 N999 N998 N017 AD8606
XU6 N012 N011 N999 N998 N018 AD8606
V1 N019 0 0.1880225988700565 Rser=0
V2 N020 0 0.07435028248587572 Rser=0
V3 N021 0 0.15344632768361582 Rser=0
V4 N022 0 0.048361581920903965 Rser=0
V5 N023 0 0.03593220338983052 Rser=0
V6 N024 0 0.2 Rser=0
V999 N999 0 3 Rser=0
V998 0 N998 3 Rser=0
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
