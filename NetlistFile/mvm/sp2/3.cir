* ltspice_circuit_netlist
R73 0 N001 34754.632376084395
R74 0 N002 4291.981811699848
R75 0 N003 34045.92769716507
R76 0 N004 3983.764746192914
R77 0 N005 31525.78676666636
R78 0 N006 3597.8150621726527
R79 0 N007 33290.755989224344
R80 0 N008 3368.0021475901513
R81 0 N009 31681.82356239132
R82 0 N010 3623.0160748546477
R83 0 N011 31797.328162986258
R84 0 N012 3333.3333333333335
R1 N001 N019 20775.87758339517
R37 N002 N019 30771.389535609338
R2 N001 N020 17549.9898212243
R38 N002 N020 25093.179698525357
R3 N001 N021 22495.73743064327
R39 N002 N021 30898.71907653318
R4 N001 N022 14382.357014810526
R40 N002 N022 23285.805742266766
R5 N001 N023 24492.79888697399
R41 N002 N023 31904.069595782403
R6 N001 N024 14593.72528780589
R42 N002 N024 22501.94519341624
R7 N003 N019 14925.36985355396
R43 N004 N019 23276.119631699665
R8 N003 N020 22309.714453497858
R44 N004 N020 32746.10105134947
R9 N003 N021 19929.271562696733
R45 N004 N021 27738.93557035149
R10 N003 N022 21098.14314242497
R46 N004 N022 30267.5108173411
R11 N003 N023 11362.978980001884
R47 N004 N023 18544.55713000443
R12 N003 N024 15229.046078258529
R48 N004 N024 22097.535879980947
R13 N005 N019 10677.64883759235
R49 N006 N019 17127.961822929065
R14 N005 N020 20172.587472689418
R50 N006 N020 28348.318743357777
R15 N005 N021 13118.994252471834
R51 N006 N021 21026.836235393184
R16 N005 N022 11911.425476743598
R52 N006 N022 19714.77052662862
R17 N005 N023 18354.06881459329
R53 N006 N023 26958.120525599923
R18 N005 N024 18050.847080872725
R54 N006 N024 26265.323272704194
R19 N007 N019 15611.106229205492
R55 N008 N019 23706.946174662018
R20 N007 N020 11134.533815829056
R56 N008 N020 18543.271603742778
R21 N007 N021 19841.61640405748
R57 N008 N021 27863.23235855227
R22 N007 N022 13880.860437449322
R58 N008 N022 22013.38706345966
R23 N007 N023 12150.083606088325
R59 N008 N023 19659.235484506007
R24 N007 N024 10711.023734102539
R60 N008 N024 17519.51948067912
R25 N009 N019 17552.623941706523
R61 N010 N019 25042.413075042532
R26 N009 N020 11018.810539943392
R62 N010 N020 18448.35476942828
R27 N009 N021 13650.53785387325
R63 N010 N021 22414.19938676913
R28 N009 N022 18072.04228954968
R64 N010 N022 26484.518726855888
R29 N009 N023 18320.65131334879
R65 N010 N023 26120.528564193028
R30 N009 N024 12407.130045925278
R66 N010 N024 18870.935993891835
R31 N011 N019 13327.689408036278
R67 N012 N019 20697.939148735764
R32 N011 N020 20507.78123064778
R68 N012 N020 30109.40757989907
R33 N011 N021 14361.959248671163
R69 N012 N021 22144.500139644704
R34 N011 N022 11508.005680255288
R70 N012 N022 18473.351853546337
R35 N011 N023 11376.106249666373
R71 N012 N023 18908.67120521052
R36 N011 N024 11072.349310263344
R72 N012 N024 18022.980011696916
R85 N001 N013 10000
R86 N003 N014 10000
R87 N005 N015 10000
R88 N007 N016 10000
R89 N009 N017 10000
R90 N011 N018 10000
XU1 N002 N001 N999 N998 N013 AD8606
XU2 N004 N003 N999 N998 N014 AD8606
XU3 N006 N005 N999 N998 N015 AD8606
XU4 N008 N007 N999 N998 N016 AD8606
XU5 N010 N009 N999 N998 N017 AD8606
XU6 N012 N011 N999 N998 N018 AD8606
V1 N019 0 0.2 Rser=0
V2 N020 0 0.15585893060295794 Rser=0
V3 N021 0 0.14721274175199092 Rser=0
V4 N022 0 0.14448236632536976 Rser=0
V5 N023 0 0.04482366325369739 Rser=0
V6 N024 0 0.03435722411831628 Rser=0
V999 N999 0 3 Rser=0
V998 0 N998 3 Rser=0
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
