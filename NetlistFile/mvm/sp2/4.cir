* ltspice_circuit_netlist
R73 0 N001 34615.90354119941
R74 0 N002 4288.525737940722
R75 0 N003 31254.769403400434
R76 0 N004 3984.335439782592
R77 0 N005 32349.41739975523
R78 0 N006 3579.015032021071
R79 0 N007 33288.59504057642
R80 0 N008 3366.4548764063934
R81 0 N009 34296.830737550365
R82 0 N010 3640.620695810486
R83 0 N011 33220.62706379314
R84 0 N012 3358.011003764762
R1 N001 N019 20868.71446970246
R37 N002 N019 31589.47742860793
R2 N001 N020 17023.002186345024
R38 N002 N020 25909.22151763709
R3 N001 N021 23082.324372311927
R39 N002 N021 31241.697021277665
R4 N001 N022 14237.568051426353
R40 N002 N022 21977.276385583245
R5 N001 N023 23722.044394117387
R41 N002 N023 34011.526528979964
R6 N001 N024 14399.400994361335
R42 N002 N024 23291.501124574632
R7 N003 N019 14926.17402679908
R43 N004 N019 24589.484356211466
R8 N003 N020 22321.10427417456
R44 N004 N020 30513.676691165616
R9 N003 N021 20201.27635652029
R45 N004 N021 27654.505490003787
R10 N003 N022 21048.965097546177
R46 N004 N022 30017.007768460342
R11 N003 N023 11251.748489033234
R47 N004 N023 18351.353264423986
R12 N003 N024 15034.875585824393
R48 N004 N024 22959.06182618769
R13 N005 N019 10500.539528114157
R49 N006 N019 17215.944572751454
R14 N005 N020 20270.956691325526
R50 N006 N020 29414.07132268152
R15 N005 N021 13306.391399568101
R51 N006 N021 20737.049686621423
R16 N005 N022 11728.901541479554
R52 N006 N022 19228.830337760184
R17 N005 N023 17939.909721587046
R53 N006 N023 28196.24199115405
R18 N005 N024 18434.98859594473
R54 N006 N024 26645.62971511976
R19 N007 N019 15635.491360284093
R55 N008 N019 23517.227257023897
R20 N007 N020 11353.109366134107
R56 N008 N020 17771.389980690856
R21 N007 N021 19795.001100860827
R57 N008 N021 28077.798964747293
R22 N007 N022 13751.944972473773
R58 N008 N022 21551.68109276315
R23 N007 N023 12342.775018046746
R59 N008 N023 19888.72632160108
R24 N007 N024 10635.44518235235
R60 N008 N024 17516.297620443518
R25 N009 N019 17462.676040294264
R61 N010 N019 25039.5974326738
R26 N009 N020 11070.268157576002
R62 N010 N020 18041.22201121684
R27 N009 N021 13930.843846602105
R63 N010 N021 23239.648464897073
R28 N009 N022 17892.5403406713
R64 N010 N022 27103.750990416895
R29 N009 N023 17879.482054400687
R65 N010 N023 26096.36309785217
R30 N009 N024 12448.335167411748
R66 N010 N024 20411.387398879615
R31 N011 N019 13655.982443284875
R67 N012 N019 20505.370742331088
R32 N011 N020 20241.890159573748
R68 N012 N020 29704.953739649754
R33 N011 N021 14211.111812277068
R69 N012 N021 22501.248040733764
R34 N011 N022 11454.289504560667
R70 N012 N022 18793.555221206694
R35 N011 N023 11299.779162533167
R71 N012 N023 18969.627760092204
R36 N011 N024 10968.838845598986
R72 N012 N024 18459.224220045464
R85 N001 N013 10000
R86 N003 N014 10000
R87 N005 N015 10000
R88 N007 N016 10000
R89 N009 N017 10000
R90 N011 N018 10000
XU1 N002 N001 N999 N998 N013 AD8606
XU2 N004 N003 N999 N998 N014 AD8606
XU3 N006 N005 N999 N998 N015 AD8606
XU4 N008 N007 N999 N998 N016 AD8606
XU5 N010 N009 N999 N998 N017 AD8606
XU6 N012 N011 N999 N998 N018 AD8606
V1 N019 0 0.09988385598141696 Rser=0
V2 N020 0 0.1124274099883856 Rser=0
V3 N021 0 0.07642276422764228 Rser=0
V4 N022 0 0.2 Rser=0
V5 N023 0 0.1523809523809524 Rser=0
V6 N024 0 0.16190476190476194 Rser=0
V999 N999 0 3 Rser=0
V998 0 N998 3 Rser=0
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
