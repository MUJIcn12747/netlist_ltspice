* ltspice_circuit_netlist
R73 0 N001 35121.90814308186
R74 0 N002 4288.451725370613
R75 0 N003 33520.82513956205
R76 0 N004 3947.999798397659
R77 0 N005 32137.47158593453
R78 0 N006 3618.1786838449684
R79 0 N007 34029.24956219786
R80 0 N008 3361.759715025216
R81 0 N009 34633.859119095025
R82 0 N010 3663.580061281781
R83 0 N011 32891.04147289451
R84 0 N012 3333.3333333333335
R1 N001 N019 21291.940552626438
R37 N002 N019 30623.356257335952
R2 N001 N020 17596.43825030827
R38 N002 N020 26236.84513073463
R3 N001 N021 21933.579740651723
R39 N002 N021 29574.490311915437
R4 N001 N022 14319.284263066289
R40 N002 N022 21830.29923557102
R5 N001 N023 25388.55775156059
R41 N002 N023 33777.216433881236
R6 N001 N024 14486.35495844309
R42 N002 N024 21415.471463319547
R7 N003 N019 15256.013244834192
R43 N004 N019 22476.28931700486
R8 N003 N020 23190.412542516293
R44 N004 N020 31466.708236881455
R9 N003 N021 19305.265649457462
R45 N004 N021 28647.54152104564
R10 N003 N022 22515.68706296682
R46 N004 N022 30043.257477252337
R11 N003 N023 11249.314815469828
R47 N004 N023 17574.98856829543
R12 N003 N024 14806.549421697227
R48 N004 N024 22505.691194759103
R13 N005 N019 10638.519383258385
R49 N006 N019 17595.214784405453
R14 N005 N020 19809.600106452745
R50 N006 N020 29793.03793593474
R15 N005 N021 13341.975699402166
R51 N006 N021 20461.467560387697
R16 N005 N022 11557.051746673193
R52 N006 N022 19450.782768953213
R17 N005 N023 17988.20239323091
R53 N006 N023 27016.650372831613
R18 N005 N024 17977.85683546258
R54 N006 N024 26321.217211689254
R19 N007 N019 15722.369472336117
R55 N008 N019 23855.464954908646
R20 N007 N020 11226.548173840752
R56 N008 N020 18422.86467313466
R21 N007 N021 19498.96042255303
R57 N008 N021 27909.028384498615
R22 N007 N022 13506.021365790846
R58 N008 N022 21607.395467386952
R23 N007 N023 12683.018108023633
R59 N008 N023 19059.92129899373
R24 N007 N024 11037.077933654518
R60 N008 N024 17589.91640312328
R25 N009 N019 17295.250583813944
R61 N010 N019 26413.394330159557
R26 N009 N020 11098.608818226368
R62 N010 N020 17988.590249706416
R27 N009 N021 13781.97564107615
R63 N010 N021 21800.79241804513
R28 N009 N022 18231.28815597824
R64 N010 N022 27172.828729727233
R29 N009 N023 17415.665413417075
R65 N010 N023 25714.99741439681
R30 N009 N024 12592.81439695991
R66 N010 N024 20910.786227316632
R31 N011 N019 13112.185315075785
R67 N012 N019 20728.77523076257
R32 N011 N020 20938.317533955185
R68 N012 N020 29060.404333544433
R33 N011 N021 14161.91085249192
R69 N012 N021 22369.41919622885
R34 N011 N022 11655.723809261995
R70 N012 N022 18963.968022174577
R35 N011 N023 11379.847612390642
R71 N012 N023 18437.45556469009
R36 N011 N024 11123.154470854664
R72 N012 N024 17727.087019795475
R85 N001 N013 10000
R86 N003 N014 10000
R87 N005 N015 10000
R88 N007 N016 10000
R89 N009 N017 10000
R90 N011 N018 10000
XU1 N002 N001 N999 N998 N013 AD8606
XU2 N004 N003 N999 N998 N014 AD8606
XU3 N006 N005 N999 N998 N015 AD8606
XU4 N008 N007 N999 N998 N016 AD8606
XU5 N010 N009 N999 N998 N017 AD8606
XU6 N012 N011 N999 N998 N018 AD8606
V1 N019 0 0.2 Rser=0
V2 N020 0 0.1908872901678657 Rser=0
V3 N021 0 0.057074340527577934 Rser=0
V4 N022 0 0.12661870503597122 Rser=0
V5 N023 0 0.07625899280575542 Rser=0
V6 N024 0 0.1964028776978417 Rser=0
V999 N999 0 3 Rser=0
V998 0 N998 3 Rser=0
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
