* ltspice_circuit_netlist
R73 0 N001 32416.68718907621
R74 0 N002 4260.67347262089
R75 0 N003 31844.906669853215
R76 0 N004 3963.2663826201033
R77 0 N005 33849.587425258156
R78 0 N006 3609.9300980317385
R79 0 N007 32407.586257673873
R80 0 N008 3399.057986292793
R81 0 N009 32787.47697208878
R82 0 N010 3628.8788992236564
R83 0 N011 33370.56113837189
R84 0 N012 3333.3333333333335
R1 N001 N019 20924.838650199166
R37 N002 N019 28187.641137514798
R2 N001 N020 17434.897103319927
R38 N002 N020 25993.092099088197
R3 N001 N021 21699.78077149386
R39 N002 N021 31407.498565945454
R4 N001 N022 13988.403521198143
R40 N002 N022 21717.154567059883
R5 N001 N023 24021.766134987283
R41 N002 N023 32691.68875204087
R6 N001 N024 14888.74367194155
R42 N002 N024 22385.20796123938
R7 N003 N019 15253.41084872444
R43 N004 N019 23691.58636971521
R8 N003 N020 23321.747346434888
R44 N004 N020 31244.309950237363
R9 N003 N021 19694.39931552801
R45 N004 N021 26027.124077164543
R10 N003 N022 22376.50301813367
R46 N004 N022 30609.55464726646
R11 N003 N023 11106.972130251876
R47 N004 N023 17837.606063060543
R12 N003 N024 14583.888381916417
R48 N004 N024 22489.010948954827
R13 N005 N019 10529.006118685127
R49 N006 N019 17688.6160518623
R14 N005 N020 19915.381195460744
R50 N006 N020 27277.202018750337
R15 N005 N021 13180.63462008094
R51 N006 N021 21019.729601487288
R16 N005 N022 11847.971832288531
R52 N006 N022 18515.969820016187
R17 N005 N023 17846.567469300782
R53 N006 N023 27077.82513753616
R18 N005 N024 18182.065508526794
R54 N006 N024 27095.809061230084
R19 N007 N019 15360.253632813969
R55 N008 N019 23083.911139820513
R20 N007 N020 11460.156202959484
R56 N008 N020 18821.404043903127
R21 N007 N021 19738.67359174747
R57 N008 N021 27760.66719103984
R22 N007 N022 13699.433105084647
R58 N008 N022 20944.949758631414
R23 N007 N023 12201.913234222626
R59 N008 N023 19815.63917915969
R24 N007 N024 10618.856642809691
R60 N008 N024 17644.148199745192
R25 N009 N019 17658.721922401306
R61 N010 N019 24856.020816092463
R26 N009 N020 11059.255555757323
R62 N010 N020 18599.04407014487
R27 N009 N021 13696.478334123876
R63 N010 N021 22164.958921440135
R28 N009 N022 18874.10614931005
R64 N010 N022 28777.251068690293
R29 N009 N023 17828.533956730273
R65 N010 N023 25953.55247384552
R30 N009 N024 12207.882640548238
R66 N010 N024 19967.195535965133
R31 N011 N019 13124.782257641109
R67 N012 N019 21448.050350821646
R32 N011 N020 21090.127934090622
R68 N012 N020 27915.312738441316
R33 N011 N021 14269.207392876013
R69 N012 N021 21370.603732814634
R34 N011 N022 11396.6857532526
R70 N012 N022 19022.391358234876
R35 N011 N023 11645.44961956426
R71 N012 N023 19144.948744571557
R36 N011 N024 11162.148701147125
R72 N012 N024 18000.64404781892
R85 N001 N013 10000
R86 N003 N014 10000
R87 N005 N015 10000
R88 N007 N016 10000
R89 N009 N017 10000
R90 N011 N018 10000
XU1 N002 N001 N999 N998 N013 AD8606
XU2 N004 N003 N999 N998 N014 AD8606
XU3 N006 N005 N999 N998 N015 AD8606
XU4 N008 N007 N999 N998 N016 AD8606
XU5 N010 N009 N999 N998 N017 AD8606
XU6 N012 N011 N999 N998 N018 AD8606
V1 N019 0 0.07369668246445497 Rser=0
V2 N020 0 0.10023696682464457 Rser=0
V3 N021 0 0.183175355450237 Rser=0
V4 N022 0 0.2 Rser=0
V5 N023 0 0.06469194312796209 Rser=0
V6 N024 0 0.17725118483412325 Rser=0
V999 N999 0 3 Rser=0
V998 0 N998 3 Rser=0
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
