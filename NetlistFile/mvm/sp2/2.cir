* ltspice_circuit_netlist
R73 0 N001 30658.24544986776
R74 0 N002 4258.609711102294
R75 0 N003 33241.18397481119
R76 0 N004 3978.7197824752548
R77 0 N005 33996.161661196405
R78 0 N006 3636.8498702303573
R79 0 N007 32415.93539077295
R80 0 N008 3378.457806580623
R81 0 N009 33730.00872712847
R82 0 N010 3642.2990828592924
R83 0 N011 36349.63789056388
R84 0 N012 3333.3333333333335
R1 N001 N019 20236.271599873264
R37 N002 N019 30743.30102880926
R2 N001 N020 17036.953557466233
R38 N002 N020 26527.081810351945
R3 N001 N021 21871.686543259155
R39 N002 N021 31491.040974952182
R4 N001 N022 14090.002302674808
R40 N002 N022 22333.410013297227
R5 N001 N023 23531.793945251266
R41 N002 N023 33623.872882796255
R6 N001 N024 14211.952072725557
R42 N002 N024 22493.164334621037
R7 N003 N019 14863.358581741797
R43 N004 N019 23675.506432286893
R8 N003 N020 21907.91744580466
R44 N004 N020 31139.632208100382
R9 N003 N021 20415.014756927703
R45 N004 N021 27834.966866946444
R10 N003 N022 21642.853834026744
R46 N004 N022 31949.363968387373
R11 N003 N023 11321.209106820406
R47 N004 N023 18750.03503760325
R12 N003 N024 14685.653296219753
R48 N004 N024 22725.125918584403
R13 N005 N019 10539.841716416919
R49 N006 N019 17840.211070353325
R14 N005 N020 19688.10012508349
R50 N006 N020 28882.024122292947
R15 N005 N021 13544.720467457948
R51 N006 N021 21977.720744500766
R16 N005 N022 11785.384607157452
R52 N006 N022 19176.86168892062
R17 N005 N023 18527.974162972972
R53 N006 N023 27564.553518548873
R18 N005 N024 18946.35320140884
R54 N006 N024 25121.572531374342
R19 N007 N019 16045.071770173028
R55 N008 N019 23162.51347535426
R20 N007 N020 11082.710466567612
R56 N008 N020 18820.1797023028
R21 N007 N021 19380.386537489052
R57 N008 N021 26227.314836036465
R22 N007 N022 14080.803877632141
R58 N008 N022 21285.334229798314
R23 N007 N023 12288.105154821305
R59 N008 N023 19699.44660962725
R24 N007 N024 10838.967437591871
R60 N008 N024 17303.969146584008
R25 N009 N019 17713.279778479617
R61 N010 N019 26423.594758567022
R26 N009 N020 11036.503808039006
R62 N010 N020 18074.229754674936
R27 N009 N021 13712.717783415066
R63 N010 N021 21176.0239987797
R28 N009 N022 19399.46638742692
R64 N010 N022 26431.76561779111
R29 N009 N023 18131.079267002868
R65 N010 N023 24888.401536609847
R30 N009 N024 12621.918942212042
R66 N010 N024 19821.31834059513
R31 N011 N019 13133.391957819998
R67 N012 N019 20942.301461775736
R32 N011 N020 21371.289365422203
R68 N012 N020 30146.196396365314
R33 N011 N021 14193.269189286804
R69 N012 N021 22451.937105195786
R34 N011 N022 11375.35745857604
R70 N012 N022 18889.880957778598
R35 N011 N023 11282.862394008987
R71 N012 N023 18315.610104965897
R36 N011 N024 10984.56373846699
R72 N012 N024 18331.23180717425
R85 N001 N013 10000
R86 N003 N014 10000
R87 N005 N015 10000
R88 N007 N016 10000
R89 N009 N017 10000
R90 N011 N018 10000
XU1 N002 N001 N999 N998 N013 AD8606
XU2 N004 N003 N999 N998 N014 AD8606
XU3 N006 N005 N999 N998 N015 AD8606
XU4 N008 N007 N999 N998 N016 AD8606
XU5 N010 N009 N999 N998 N017 AD8606
XU6 N012 N011 N999 N998 N018 AD8606
V1 N019 0 0.05724299065420561 Rser=0
V2 N020 0 0.2 Rser=0
V3 N021 0 0.19112149532710282 Rser=0
V4 N022 0 0.1899532710280374 Rser=0
V5 N023 0 0.13808411214953273 Rser=0
V6 N024 0 0.043224299065420566 Rser=0
V999 N999 0 3 Rser=0
V998 0 N998 3 Rser=0
.lib LTC.lib
.lib ADI.lib
.tran 1n 10u
.backanno
.end
